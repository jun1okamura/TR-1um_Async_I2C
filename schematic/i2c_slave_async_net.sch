v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 800 0 0 0 {name=_336_}
N 830 -40 830 -60 {}
C {devices/lab_pin.sym} 830 -60 0 0 {name=l1 lab=VDD}
N 780 0 760 0 {}
C {devices/lab_pin.sym} 760 0 0 0 {name=l2 lab=bit_cnt[0]}
N 900 0 920 0 {}
C {devices/lab_pin.sym} 920 0 0 0 {name=l3 lab=_110_}
N 830 40 830 60 {}
C {devices/lab_pin.sym} 830 60 0 0 {name=l4 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1150 0 0 0 {name=_337_}
N 1180 -40 1180 -60 {}
C {devices/lab_pin.sym} 1180 -60 0 0 {name=l5 lab=VDD}
N 1130 0 1110 0 {}
C {devices/lab_pin.sym} 1110 0 0 0 {name=l6 lab=bit_cnt[1]}
N 1250 0 1270 0 {}
C {devices/lab_pin.sym} 1270 0 0 0 {name=l7 lab=_111_}
N 1180 40 1180 60 {}
C {devices/lab_pin.sym} 1180 60 0 0 {name=l8 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1500 0 0 0 {name=_338_}
N 1530 -40 1530 -60 {}
C {devices/lab_pin.sym} 1530 -60 0 0 {name=l9 lab=VDD}
N 1480 0 1460 0 {}
C {devices/lab_pin.sym} 1460 0 0 0 {name=l10 lab=bit_cnt[2]}
N 1600 0 1620 0 {}
C {devices/lab_pin.sym} 1620 0 0 0 {name=l11 lab=_112_}
N 1530 40 1530 60 {}
C {devices/lab_pin.sym} 1530 60 0 0 {name=l12 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1850 0 0 0 {name=_339_}
N 1880 -40 1880 -60 {}
C {devices/lab_pin.sym} 1880 -60 0 0 {name=l13 lab=VDD}
N 1830 0 1810 0 {}
C {devices/lab_pin.sym} 1810 0 0 0 {name=l14 lab=_005_}
N 1950 0 1970 0 {}
C {devices/lab_pin.sym} 1970 0 0 0 {name=l15 lab=_113_}
N 1880 40 1880 60 {}
C {devices/lab_pin.sym} 1880 60 0 0 {name=l16 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2200 0 0 0 {name=_340_}
N 2230 -40 2230 -60 {}
C {devices/lab_pin.sym} 2230 -60 0 0 {name=l17 lab=VDD}
N 2180 0 2160 0 {}
C {devices/lab_pin.sym} 2160 0 0 0 {name=l18 lab=_006_}
N 2300 0 2320 0 {}
C {devices/lab_pin.sym} 2320 0 0 0 {name=l19 lab=_114_}
N 2230 40 2230 60 {}
C {devices/lab_pin.sym} 2230 60 0 0 {name=l20 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2550 0 0 0 {name=_341_}
N 2580 -40 2580 -60 {}
C {devices/lab_pin.sym} 2580 -60 0 0 {name=l21 lab=VDD}
N 2530 0 2510 0 {}
C {devices/lab_pin.sym} 2510 0 0 0 {name=l22 lab=rw}
N 2650 0 2670 0 {}
C {devices/lab_pin.sym} 2670 0 0 0 {name=l23 lab=_115_}
N 2580 40 2580 60 {}
C {devices/lab_pin.sym} 2580 60 0 0 {name=l24 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2900 0 0 0 {name=_342_}
N 2930 -40 2930 -60 {}
C {devices/lab_pin.sym} 2930 -60 0 0 {name=l25 lab=VDD}
N 2880 0 2860 0 {}
C {devices/lab_pin.sym} 2860 0 0 0 {name=l26 lab=rst_n}
N 3000 0 3020 0 {}
C {devices/lab_pin.sym} 3020 0 0 0 {name=l27 lab=_116_}
N 2930 40 2930 60 {}
C {devices/lab_pin.sym} 2930 60 0 0 {name=l28 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3250 0 0 0 {name=_343_}
N 3280 -40 3280 -60 {}
C {devices/lab_pin.sym} 3280 -60 0 0 {name=l29 lab=VDD}
N 3230 0 3210 0 {}
C {devices/lab_pin.sym} 3210 0 0 0 {name=l30 lab=sda_d}
N 3350 0 3370 0 {}
C {devices/lab_pin.sym} 3370 0 0 0 {name=l31 lab=_117_}
N 3280 40 3280 60 {}
C {devices/lab_pin.sym} 3280 60 0 0 {name=l32 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 3600 0 0 0 {name=_344_}
N 3630 -60 3630 -80 {}
C {devices/lab_pin.sym} 3630 -80 0 0 {name=l33 lab=VDD}
N 3710 0 3730 0 {}
C {devices/lab_pin.sym} 3730 0 0 0 {name=l34 lab=_118_}
N 3580 -20 3560 -20 {}
C {devices/lab_pin.sym} 3560 -20 0 0 {name=l35 lab=phase[2]}
N 3580 20 3560 20 {}
C {devices/lab_pin.sym} 3560 20 0 0 {name=l36 lab=_008_}
N 3630 60 3630 80 {}
C {devices/lab_pin.sym} 3630 80 0 0 {name=l37 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3950 0 0 0 {name=_345_}
N 3980 -60 3980 -80 {}
C {devices/lab_pin.sym} 3980 -80 0 0 {name=l38 lab=VDD}
N 4060 0 4080 0 {}
C {devices/lab_pin.sym} 4080 0 0 0 {name=l39 lab=rx_valid}
N 3930 -20 3910 -20 {}
C {devices/lab_pin.sym} 3910 -20 0 0 {name=l40 lab=_014_}
N 3930 20 3910 20 {}
C {devices/lab_pin.sym} 3910 20 0 0 {name=l41 lab=_118_}
N 3980 60 3980 80 {}
C {devices/lab_pin.sym} 3980 80 0 0 {name=l42 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4300 0 0 0 {name=_346_}
N 4330 -60 4330 -80 {}
C {devices/lab_pin.sym} 4330 -80 0 0 {name=l43 lab=VDD}
N 4410 0 4430 0 {}
C {devices/lab_pin.sym} 4430 0 0 0 {name=l44 lab=_119_}
N 4280 -20 4260 -20 {}
C {devices/lab_pin.sym} 4260 -20 0 0 {name=l45 lab=phase[0]}
N 4280 20 4260 20 {}
C {devices/lab_pin.sym} 4260 20 0 0 {name=l46 lab=_118_}
N 4330 60 4330 80 {}
C {devices/lab_pin.sym} 4330 80 0 0 {name=l47 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 4650 0 0 0 {name=_347_}
N 4680 -60 4680 -80 {}
C {devices/lab_pin.sym} 4680 -80 0 0 {name=l48 lab=VDD}
N 4760 0 4780 0 {}
C {devices/lab_pin.sym} 4780 0 0 0 {name=l49 lab=_120_}
N 4630 -20 4610 -20 {}
C {devices/lab_pin.sym} 4610 -20 0 0 {name=l50 lab=phase[1]}
N 4630 20 4610 20 {}
C {devices/lab_pin.sym} 4610 20 0 0 {name=l51 lab=phase[0]}
N 4680 60 4680 80 {}
C {devices/lab_pin.sym} 4680 80 0 0 {name=l52 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 800 300 0 0 {name=_348_}
N 830 240 830 220 {}
C {devices/lab_pin.sym} 830 220 0 0 {name=l53 lab=VDD}
N 910 300 930 300 {}
C {devices/lab_pin.sym} 930 300 0 0 {name=l54 lab=_121_}
N 780 280 760 280 {}
C {devices/lab_pin.sym} 760 280 0 0 {name=l55 lab=phase[2]}
N 780 320 760 320 {}
C {devices/lab_pin.sym} 760 320 0 0 {name=l56 lab=_120_}
N 830 360 830 380 {}
C {devices/lab_pin.sym} 830 380 0 0 {name=l57 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1150 300 0 0 {name=_349_}
N 1180 240 1180 220 {}
C {devices/lab_pin.sym} 1180 220 0 0 {name=l58 lab=VDD}
N 1260 300 1280 300 {}
C {devices/lab_pin.sym} 1280 300 0 0 {name=l59 lab=_046_}
N 1130 280 1110 280 {}
C {devices/lab_pin.sym} 1110 280 0 0 {name=l60 lab=_007_}
N 1130 320 1110 320 {}
C {devices/lab_pin.sym} 1110 320 0 0 {name=l61 lab=_120_}
N 1180 360 1180 380 {}
C {devices/lab_pin.sym} 1180 380 0 0 {name=l62 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1500 300 0 0 {name=_350_}
N 1530 260 1530 240 {}
C {devices/lab_pin.sym} 1530 240 0 0 {name=l63 lab=VDD}
N 1480 300 1460 300 {}
C {devices/lab_pin.sym} 1460 300 0 0 {name=l64 lab=_046_}
N 1600 300 1620 300 {}
C {devices/lab_pin.sym} 1620 300 0 0 {name=l65 lab=_047_}
N 1530 340 1530 360 {}
C {devices/lab_pin.sym} 1530 360 0 0 {name=l66 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 1850 300 0 0 {name=_351_}
N 1830 300 1810 300 {}
C {devices/lab_pin.sym} 1810 300 0 0 {name=l67 lab=_121_}
N 1830 320 1810 320 {}
C {devices/lab_pin.sym} 1810 320 0 0 {name=l68 lab=_046_}
N 1880 240 1880 220 {}
C {devices/lab_pin.sym} 1880 220 0 0 {name=l69 lab=VDD}
N 1960 300 1980 300 {}
C {devices/lab_pin.sym} 1980 300 0 0 {name=l70 lab=_048_}
N 1830 280 1810 280 {}
C {devices/lab_pin.sym} 1810 280 0 0 {name=l71 lab=_119_}
N 1880 360 1880 380 {}
C {devices/lab_pin.sym} 1880 380 0 0 {name=l72 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR3.sym} 2200 300 0 0 {name=_352_}
N 2180 320 2160 320 {}
C {devices/lab_pin.sym} 2160 320 0 0 {name=l73 lab=_046_}
N 2230 240 2230 220 {}
C {devices/lab_pin.sym} 2230 220 0 0 {name=l74 lab=VDD}
N 2310 300 2330 300 {}
C {devices/lab_pin.sym} 2330 300 0 0 {name=l75 lab=_049_}
N 2180 280 2160 280 {}
C {devices/lab_pin.sym} 2160 280 0 0 {name=l76 lab=_119_}
N 2180 300 2160 300 {}
C {devices/lab_pin.sym} 2160 300 0 0 {name=l77 lab=_121_}
N 2230 360 2230 380 {}
C {devices/lab_pin.sym} 2230 380 0 0 {name=l78 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 2550 300 0 0 {name=_353_}
N 2580 240 2580 220 {}
C {devices/lab_pin.sym} 2580 220 0 0 {name=l79 lab=VDD}
N 2660 300 2680 300 {}
C {devices/lab_pin.sym} 2680 300 0 0 {name=l80 lab=_050_}
N 2530 280 2510 280 {}
C {devices/lab_pin.sym} 2510 280 0 0 {name=l81 lab=_014_}
N 2530 320 2510 320 {}
C {devices/lab_pin.sym} 2510 320 0 0 {name=l82 lab=phase[1]}
N 2580 360 2580 380 {}
C {devices/lab_pin.sym} 2580 380 0 0 {name=l83 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2900 300 0 0 {name=_354_}
N 2930 240 2930 220 {}
C {devices/lab_pin.sym} 2930 220 0 0 {name=l84 lab=VDD}
N 3010 300 3030 300 {}
C {devices/lab_pin.sym} 3030 300 0 0 {name=l85 lab=_051_}
N 2880 280 2860 280 {}
C {devices/lab_pin.sym} 2860 280 0 0 {name=l86 lab=_007_}
N 2880 320 2860 320 {}
C {devices/lab_pin.sym} 2860 320 0 0 {name=l87 lab=_050_}
N 2930 360 2930 380 {}
C {devices/lab_pin.sym} 2930 380 0 0 {name=l88 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3250 300 0 0 {name=_355_}
N 3280 240 3280 220 {}
C {devices/lab_pin.sym} 3280 220 0 0 {name=l89 lab=VDD}
N 3360 300 3380 300 {}
C {devices/lab_pin.sym} 3380 300 0 0 {name=l90 lab=_052_}
N 3230 280 3210 280 {}
C {devices/lab_pin.sym} 3210 280 0 0 {name=l91 lab=phase[2]}
N 3230 320 3210 320 {}
C {devices/lab_pin.sym} 3210 320 0 0 {name=l92 lab=_050_}
N 3280 360 3280 380 {}
C {devices/lab_pin.sym} 3280 380 0 0 {name=l93 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 3600 300 0 0 {name=_356_}
N 3590 270 3590 250 {}
C {devices/lab_pin.sym} 3590 250 0 0 {name=l94 lab=rx_valid}
N 3590 290 3570 290 {}
C {devices/lab_pin.sym} 3570 290 0 0 {name=l95 lab=_049_}
N 3590 310 3570 310 {}
C {devices/lab_pin.sym} 3570 310 0 0 {name=l96 lab=_051_}
N 3590 330 3590 350 {}
C {devices/lab_pin.sym} 3590 350 0 0 {name=l97 lab=_052_}
N 3630 240 3630 220 {}
C {devices/lab_pin.sym} 3630 220 0 0 {name=l98 lab=VDD}
N 3710 300 3730 300 {}
C {devices/lab_pin.sym} 3730 300 0 0 {name=l99 lab=_053_}
N 3630 360 3630 380 {}
C {devices/lab_pin.sym} 3630 380 0 0 {name=l100 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3950 300 0 0 {name=_357_}
N 3980 260 3980 240 {}
C {devices/lab_pin.sym} 3980 240 0 0 {name=l101 lab=VDD}
N 3930 300 3910 300 {}
C {devices/lab_pin.sym} 3910 300 0 0 {name=l102 lab=_053_}
N 4050 300 4070 300 {}
C {devices/lab_pin.sym} 4070 300 0 0 {name=l103 lab=_054_}
N 3980 340 3980 360 {}
C {devices/lab_pin.sym} 3980 360 0 0 {name=l104 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 4300 300 0 0 {name=_358_}
N 4330 240 4330 220 {}
C {devices/lab_pin.sym} 4330 220 0 0 {name=l105 lab=VDD}
N 4410 300 4430 300 {}
C {devices/lab_pin.sym} 4430 300 0 0 {name=l106 lab=_055_}
N 4280 280 4260 280 {}
C {devices/lab_pin.sym} 4260 280 0 0 {name=l107 lab=bit_cnt[0]}
N 4280 320 4260 320 {}
C {devices/lab_pin.sym} 4260 320 0 0 {name=l108 lab=bit_cnt[1]}
N 4330 360 4330 380 {}
C {devices/lab_pin.sym} 4330 380 0 0 {name=l109 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4650 300 0 0 {name=_359_}
N 4680 240 4680 220 {}
C {devices/lab_pin.sym} 4680 220 0 0 {name=l110 lab=VDD}
N 4780 300 4800 300 {}
C {devices/lab_pin.sym} 4800 300 0 0 {name=l111 lab=_056_}
N 4630 280 4610 280 {}
C {devices/lab_pin.sym} 4610 280 0 0 {name=l112 lab=bit_cnt[2]}
N 4630 320 4610 320 {}
C {devices/lab_pin.sym} 4610 320 0 0 {name=l113 lab=_055_}
N 4680 360 4680 380 {}
C {devices/lab_pin.sym} 4680 380 0 0 {name=l114 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 800 600 0 0 {name=_360_}
N 790 570 790 550 {}
C {devices/lab_pin.sym} 790 550 0 0 {name=l115 lab=bit_cnt[3]}
N 790 590 770 590 {}
C {devices/lab_pin.sym} 770 590 0 0 {name=l116 lab=_009_}
N 790 610 770 610 {}
C {devices/lab_pin.sym} 770 610 0 0 {name=l117 lab=_011_}
N 790 630 790 650 {}
C {devices/lab_pin.sym} 790 650 0 0 {name=l118 lab=_010_}
N 830 540 830 520 {}
C {devices/lab_pin.sym} 830 520 0 0 {name=l119 lab=VDD}
N 910 600 930 600 {}
C {devices/lab_pin.sym} 930 600 0 0 {name=l120 lab=_057_}
N 830 660 830 680 {}
C {devices/lab_pin.sym} 830 680 0 0 {name=l121 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1150 600 0 0 {name=_361_}
N 1180 540 1180 520 {}
C {devices/lab_pin.sym} 1180 520 0 0 {name=l122 lab=VDD}
N 1260 600 1280 600 {}
C {devices/lab_pin.sym} 1280 600 0 0 {name=l123 lab=_058_}
N 1130 580 1110 580 {}
C {devices/lab_pin.sym} 1110 580 0 0 {name=l124 lab=_048_}
N 1130 620 1110 620 {}
C {devices/lab_pin.sym} 1110 620 0 0 {name=l125 lab=_057_}
N 1180 660 1180 680 {}
C {devices/lab_pin.sym} 1180 680 0 0 {name=l126 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 1500 600 0 0 {name=_362_}
N 1530 540 1530 520 {}
C {devices/lab_pin.sym} 1530 520 0 0 {name=l127 lab=VDD}
N 1610 600 1630 600 {}
C {devices/lab_pin.sym} 1630 600 0 0 {name=l128 lab=_059_}
N 1480 580 1460 580 {}
C {devices/lab_pin.sym} 1460 580 0 0 {name=l129 lab=_047_}
N 1480 620 1460 620 {}
C {devices/lab_pin.sym} 1460 620 0 0 {name=l130 lab=_058_}
N 1530 660 1530 680 {}
C {devices/lab_pin.sym} 1530 680 0 0 {name=l131 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1850 600 0 0 {name=_363_}
N 1880 540 1880 520 {}
C {devices/lab_pin.sym} 1880 520 0 0 {name=l132 lab=VDD}
N 1980 600 2000 600 {}
C {devices/lab_pin.sym} 2000 600 0 0 {name=l133 lab=_060_}
N 1830 580 1810 580 {}
C {devices/lab_pin.sym} 1810 580 0 0 {name=l134 lab=_047_}
N 1830 620 1810 620 {}
C {devices/lab_pin.sym} 1810 620 0 0 {name=l135 lab=_058_}
N 1880 660 1880 680 {}
C {devices/lab_pin.sym} 1880 680 0 0 {name=l136 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2200 600 0 0 {name=_364_}
N 2230 540 2230 520 {}
C {devices/lab_pin.sym} 2230 520 0 0 {name=l137 lab=VDD}
N 2330 600 2350 600 {}
C {devices/lab_pin.sym} 2350 600 0 0 {name=l138 lab=_061_}
N 2180 580 2160 580 {}
C {devices/lab_pin.sym} 2160 580 0 0 {name=l139 lab=_056_}
N 2180 620 2160 620 {}
C {devices/lab_pin.sym} 2160 620 0 0 {name=l140 lab=_060_}
N 2230 660 2230 680 {}
C {devices/lab_pin.sym} 2230 680 0 0 {name=l141 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2550 600 0 0 {name=_365_}
N 2580 540 2580 520 {}
C {devices/lab_pin.sym} 2580 520 0 0 {name=l142 lab=VDD}
N 2680 600 2700 600 {}
C {devices/lab_pin.sym} 2700 600 0 0 {name=l143 lab=_062_}
N 2530 580 2510 580 {}
C {devices/lab_pin.sym} 2510 580 0 0 {name=l144 lab=_054_}
N 2530 620 2510 620 {}
C {devices/lab_pin.sym} 2510 620 0 0 {name=l145 lab=_061_}
N 2580 660 2580 680 {}
C {devices/lab_pin.sym} 2580 680 0 0 {name=l146 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2900 600 0 0 {name=_366_}
N 2930 540 2930 520 {}
C {devices/lab_pin.sym} 2930 520 0 0 {name=l147 lab=VDD}
N 3030 600 3050 600 {}
C {devices/lab_pin.sym} 3050 600 0 0 {name=l148 lab=_063_}
N 2880 580 2860 580 {}
C {devices/lab_pin.sym} 2860 580 0 0 {name=l149 lab=_055_}
N 2880 620 2860 620 {}
C {devices/lab_pin.sym} 2860 620 0 0 {name=l150 lab=_060_}
N 2930 660 2930 680 {}
C {devices/lab_pin.sym} 2930 680 0 0 {name=l151 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3250 600 0 0 {name=_367_}
N 3280 540 3280 520 {}
C {devices/lab_pin.sym} 3280 520 0 0 {name=l152 lab=VDD}
N 3380 600 3400 600 {}
C {devices/lab_pin.sym} 3400 600 0 0 {name=l153 lab=_064_}
N 3230 580 3210 580 {}
C {devices/lab_pin.sym} 3210 580 0 0 {name=l154 lab=_112_}
N 3230 620 3210 620 {}
C {devices/lab_pin.sym} 3210 620 0 0 {name=l155 lab=_063_}
N 3280 660 3280 680 {}
C {devices/lab_pin.sym} 3280 680 0 0 {name=l156 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3600 600 0 0 {name=_368_}
N 3630 540 3630 520 {}
C {devices/lab_pin.sym} 3630 520 0 0 {name=l157 lab=VDD}
N 3710 600 3730 600 {}
C {devices/lab_pin.sym} 3730 600 0 0 {name=l158 lab=_015_}
N 3580 580 3560 580 {}
C {devices/lab_pin.sym} 3560 580 0 0 {name=l159 lab=_062_}
N 3580 620 3560 620 {}
C {devices/lab_pin.sym} 3560 620 0 0 {name=l160 lab=_064_}
N 3630 660 3630 680 {}
C {devices/lab_pin.sym} 3630 680 0 0 {name=l161 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3950 600 0 0 {name=_369_}
N 3980 540 3980 520 {}
C {devices/lab_pin.sym} 3980 520 0 0 {name=l162 lab=VDD}
N 4080 600 4100 600 {}
C {devices/lab_pin.sym} 4100 600 0 0 {name=l163 lab=_065_}
N 3930 580 3910 580 {}
C {devices/lab_pin.sym} 3910 580 0 0 {name=l164 lab=bit_cnt[1]}
N 3930 620 3910 620 {}
C {devices/lab_pin.sym} 3910 620 0 0 {name=l165 lab=_053_}
N 3980 660 3980 680 {}
C {devices/lab_pin.sym} 3980 680 0 0 {name=l166 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4300 600 0 0 {name=_370_}
N 4330 540 4330 520 {}
C {devices/lab_pin.sym} 4330 520 0 0 {name=l167 lab=VDD}
N 4410 600 4430 600 {}
C {devices/lab_pin.sym} 4430 600 0 0 {name=l168 lab=_066_}
N 4280 580 4260 580 {}
C {devices/lab_pin.sym} 4260 580 0 0 {name=l169 lab=bit_cnt[0]}
N 4280 620 4260 620 {}
C {devices/lab_pin.sym} 4260 620 0 0 {name=l170 lab=bit_cnt[1]}
N 4330 660 4330 680 {}
C {devices/lab_pin.sym} 4330 680 0 0 {name=l171 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR3.sym} 4650 600 0 0 {name=_371_}
N 4630 620 4610 620 {}
C {devices/lab_pin.sym} 4610 620 0 0 {name=l172 lab=_066_}
N 4680 540 4680 520 {}
C {devices/lab_pin.sym} 4680 520 0 0 {name=l173 lab=VDD}
N 4760 600 4780 600 {}
C {devices/lab_pin.sym} 4780 600 0 0 {name=l174 lab=_067_}
N 4630 580 4610 580 {}
C {devices/lab_pin.sym} 4610 580 0 0 {name=l175 lab=_055_}
N 4630 600 4610 600 {}
C {devices/lab_pin.sym} 4610 600 0 0 {name=l176 lab=_059_}
N 4680 660 4680 680 {}
C {devices/lab_pin.sym} 4680 680 0 0 {name=l177 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 800 900 0 0 {name=_372_}
N 830 840 830 820 {}
C {devices/lab_pin.sym} 830 820 0 0 {name=l178 lab=VDD}
N 930 900 950 900 {}
C {devices/lab_pin.sym} 950 900 0 0 {name=l179 lab=_016_}
N 780 880 760 880 {}
C {devices/lab_pin.sym} 760 880 0 0 {name=l180 lab=_065_}
N 780 920 760 920 {}
C {devices/lab_pin.sym} 760 920 0 0 {name=l181 lab=_067_}
N 830 960 830 980 {}
C {devices/lab_pin.sym} 830 980 0 0 {name=l182 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1150 900 0 0 {name=_373_}
N 1180 840 1180 820 {}
C {devices/lab_pin.sym} 1180 820 0 0 {name=l183 lab=VDD}
N 1280 900 1300 900 {}
C {devices/lab_pin.sym} 1300 900 0 0 {name=l184 lab=_068_}
N 1130 880 1110 880 {}
C {devices/lab_pin.sym} 1110 880 0 0 {name=l185 lab=bit_cnt[0]}
N 1130 920 1110 920 {}
C {devices/lab_pin.sym} 1110 920 0 0 {name=l186 lab=_053_}
N 1180 960 1180 980 {}
C {devices/lab_pin.sym} 1180 980 0 0 {name=l187 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1500 900 0 0 {name=_374_}
N 1530 840 1530 820 {}
C {devices/lab_pin.sym} 1530 820 0 0 {name=l188 lab=VDD}
N 1630 900 1650 900 {}
C {devices/lab_pin.sym} 1650 900 0 0 {name=l189 lab=_069_}
N 1480 880 1460 880 {}
C {devices/lab_pin.sym} 1460 880 0 0 {name=l190 lab=_009_}
N 1480 920 1460 920 {}
C {devices/lab_pin.sym} 1460 920 0 0 {name=l191 lab=_049_}
N 1530 960 1530 980 {}
C {devices/lab_pin.sym} 1530 980 0 0 {name=l192 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1850 900 0 0 {name=_375_}
N 1880 840 1880 820 {}
C {devices/lab_pin.sym} 1880 820 0 0 {name=l193 lab=VDD}
N 1980 900 2000 900 {}
C {devices/lab_pin.sym} 2000 900 0 0 {name=l194 lab=_017_}
N 1830 880 1810 880 {}
C {devices/lab_pin.sym} 1810 880 0 0 {name=l195 lab=_068_}
N 1830 920 1810 920 {}
C {devices/lab_pin.sym} 1810 920 0 0 {name=l196 lab=_069_}
N 1880 960 1880 980 {}
C {devices/lab_pin.sym} 1880 980 0 0 {name=l197 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2200 900 0 0 {name=_376_}
N 2230 840 2230 820 {}
C {devices/lab_pin.sym} 2230 820 0 0 {name=l198 lab=VDD}
N 2330 900 2350 900 {}
C {devices/lab_pin.sym} 2350 900 0 0 {name=l199 lab=_070_}
N 2180 880 2160 880 {}
C {devices/lab_pin.sym} 2160 880 0 0 {name=l200 lab=_119_}
N 2180 920 2160 920 {}
C {devices/lab_pin.sym} 2160 920 0 0 {name=l201 lab=_057_}
N 2230 960 2230 980 {}
C {devices/lab_pin.sym} 2230 980 0 0 {name=l202 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2550 900 0 0 {name=_377_}
N 2530 880 2510 880 {}
C {devices/lab_pin.sym} 2510 880 0 0 {name=l203 lab=shreg[5]}
N 2530 920 2510 920 {}
C {devices/lab_pin.sym} 2510 920 0 0 {name=l204 lab=rx_data[6]}
N 2570 940 2570 960 {}
C {devices/lab_pin.sym} 2570 960 0 0 {name=l205 lab=_070_}
N 2590 860 2610 860 {}
C {devices/lab_pin.sym} 2610 860 0 0 {name=l206 lab=VDD}
N 2620 900 2640 900 {}
C {devices/lab_pin.sym} 2640 900 0 0 {name=l207 lab=_018_}
N 2590 940 2610 940 {}
C {devices/lab_pin.sym} 2610 940 0 0 {name=l208 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2900 900 0 0 {name=_378_}
N 2880 880 2860 880 {}
C {devices/lab_pin.sym} 2860 880 0 0 {name=l209 lab=shreg[4]}
N 2880 920 2860 920 {}
C {devices/lab_pin.sym} 2860 920 0 0 {name=l210 lab=rx_data[5]}
N 2920 940 2920 960 {}
C {devices/lab_pin.sym} 2920 960 0 0 {name=l211 lab=_070_}
N 2940 860 2960 860 {}
C {devices/lab_pin.sym} 2960 860 0 0 {name=l212 lab=VDD}
N 2970 900 2990 900 {}
C {devices/lab_pin.sym} 2990 900 0 0 {name=l213 lab=_019_}
N 2940 940 2960 940 {}
C {devices/lab_pin.sym} 2960 940 0 0 {name=l214 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3250 900 0 0 {name=_379_}
N 3230 880 3210 880 {}
C {devices/lab_pin.sym} 3210 880 0 0 {name=l215 lab=shreg[3]}
N 3230 920 3210 920 {}
C {devices/lab_pin.sym} 3210 920 0 0 {name=l216 lab=rx_data[4]}
N 3270 940 3270 960 {}
C {devices/lab_pin.sym} 3270 960 0 0 {name=l217 lab=_070_}
N 3290 860 3310 860 {}
C {devices/lab_pin.sym} 3310 860 0 0 {name=l218 lab=VDD}
N 3320 900 3340 900 {}
C {devices/lab_pin.sym} 3340 900 0 0 {name=l219 lab=_020_}
N 3290 940 3310 940 {}
C {devices/lab_pin.sym} 3310 940 0 0 {name=l220 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3600 900 0 0 {name=_380_}
N 3580 880 3560 880 {}
C {devices/lab_pin.sym} 3560 880 0 0 {name=l221 lab=shreg[2]}
N 3580 920 3560 920 {}
C {devices/lab_pin.sym} 3560 920 0 0 {name=l222 lab=rx_data[3]}
N 3620 940 3620 960 {}
C {devices/lab_pin.sym} 3620 960 0 0 {name=l223 lab=_070_}
N 3640 860 3660 860 {}
C {devices/lab_pin.sym} 3660 860 0 0 {name=l224 lab=VDD}
N 3670 900 3690 900 {}
C {devices/lab_pin.sym} 3690 900 0 0 {name=l225 lab=_021_}
N 3640 940 3660 940 {}
C {devices/lab_pin.sym} 3660 940 0 0 {name=l226 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3950 900 0 0 {name=_381_}
N 3930 880 3910 880 {}
C {devices/lab_pin.sym} 3910 880 0 0 {name=l227 lab=shreg[1]}
N 3930 920 3910 920 {}
C {devices/lab_pin.sym} 3910 920 0 0 {name=l228 lab=rx_data[2]}
N 3970 940 3970 960 {}
C {devices/lab_pin.sym} 3970 960 0 0 {name=l229 lab=_070_}
N 3990 860 4010 860 {}
C {devices/lab_pin.sym} 4010 860 0 0 {name=l230 lab=VDD}
N 4020 900 4040 900 {}
C {devices/lab_pin.sym} 4040 900 0 0 {name=l231 lab=_022_}
N 3990 940 4010 940 {}
C {devices/lab_pin.sym} 4010 940 0 0 {name=l232 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 4300 900 0 0 {name=_382_}
N 4280 880 4260 880 {}
C {devices/lab_pin.sym} 4260 880 0 0 {name=l233 lab=shreg[0]}
N 4280 920 4260 920 {}
C {devices/lab_pin.sym} 4260 920 0 0 {name=l234 lab=rx_data[1]}
N 4320 940 4320 960 {}
C {devices/lab_pin.sym} 4320 960 0 0 {name=l235 lab=_070_}
N 4340 860 4360 860 {}
C {devices/lab_pin.sym} 4360 860 0 0 {name=l236 lab=VDD}
N 4370 900 4390 900 {}
C {devices/lab_pin.sym} 4390 900 0 0 {name=l237 lab=_023_}
N 4340 940 4360 940 {}
C {devices/lab_pin.sym} 4360 940 0 0 {name=l238 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 4650 900 0 0 {name=_383_}
N 4630 880 4610 880 {}
C {devices/lab_pin.sym} 4610 880 0 0 {name=l239 lab=sda_in_buf0}
N 4630 920 4610 920 {}
C {devices/lab_pin.sym} 4610 920 0 0 {name=l240 lab=rx_data[0]}
N 4670 940 4670 960 {}
C {devices/lab_pin.sym} 4670 960 0 0 {name=l241 lab=_070_}
N 4690 860 4710 860 {}
C {devices/lab_pin.sym} 4710 860 0 0 {name=l242 lab=VDD}
N 4720 900 4740 900 {}
C {devices/lab_pin.sym} 4740 900 0 0 {name=l243 lab=_024_}
N 4690 940 4710 940 {}
C {devices/lab_pin.sym} 4710 940 0 0 {name=l244 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 800 1200 0 0 {name=_384_}
N 830 1140 830 1120 {}
C {devices/lab_pin.sym} 830 1120 0 0 {name=l245 lab=VDD}
N 910 1200 930 1200 {}
C {devices/lab_pin.sym} 930 1200 0 0 {name=l246 lab=_071_}
N 780 1180 760 1180 {}
C {devices/lab_pin.sym} 760 1180 0 0 {name=l247 lab=bit_cnt[3]}
N 780 1220 760 1220 {}
C {devices/lab_pin.sym} 760 1220 0 0 {name=l248 lab=bit_cnt[2]}
N 830 1260 830 1280 {}
C {devices/lab_pin.sym} 830 1280 0 0 {name=l249 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1150 1200 0 0 {name=_385_}
N 1180 1140 1180 1120 {}
C {devices/lab_pin.sym} 1180 1120 0 0 {name=l250 lab=VDD}
N 1280 1200 1300 1200 {}
C {devices/lab_pin.sym} 1300 1200 0 0 {name=l251 lab=_072_}
N 1130 1180 1110 1180 {}
C {devices/lab_pin.sym} 1110 1180 0 0 {name=l252 lab=_066_}
N 1130 1220 1110 1220 {}
C {devices/lab_pin.sym} 1110 1220 0 0 {name=l253 lab=_071_}
N 1180 1260 1180 1280 {}
C {devices/lab_pin.sym} 1180 1280 0 0 {name=l254 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1500 1200 0 0 {name=_386_}
N 1530 1140 1530 1120 {}
C {devices/lab_pin.sym} 1530 1120 0 0 {name=l255 lab=VDD}
N 1610 1200 1630 1200 {}
C {devices/lab_pin.sym} 1630 1200 0 0 {name=l256 lab=_073_}
N 1480 1180 1460 1180 {}
C {devices/lab_pin.sym} 1460 1180 0 0 {name=l257 lab=_047_}
N 1480 1220 1460 1220 {}
C {devices/lab_pin.sym} 1460 1220 0 0 {name=l258 lab=_072_}
N 1530 1260 1530 1280 {}
C {devices/lab_pin.sym} 1530 1280 0 0 {name=l259 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 1850 1200 0 0 {name=_387_}
N 1830 1180 1810 1180 {}
C {devices/lab_pin.sym} 1810 1180 0 0 {name=l260 lab=tx_data[6]}
N 1830 1220 1810 1220 {}
C {devices/lab_pin.sym} 1810 1220 0 0 {name=l261 lab=txreg[6]}
N 1870 1240 1870 1260 {}
C {devices/lab_pin.sym} 1870 1260 0 0 {name=l262 lab=_073_}
N 1890 1160 1910 1160 {}
C {devices/lab_pin.sym} 1910 1160 0 0 {name=l263 lab=VDD}
N 1920 1200 1940 1200 {}
C {devices/lab_pin.sym} 1940 1200 0 0 {name=l264 lab=_025_}
N 1890 1240 1910 1240 {}
C {devices/lab_pin.sym} 1910 1240 0 0 {name=l265 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2200 1200 0 0 {name=_388_}
N 2180 1180 2160 1180 {}
C {devices/lab_pin.sym} 2160 1180 0 0 {name=l266 lab=tx_data[5]}
N 2180 1220 2160 1220 {}
C {devices/lab_pin.sym} 2160 1220 0 0 {name=l267 lab=txreg[5]}
N 2220 1240 2220 1260 {}
C {devices/lab_pin.sym} 2220 1260 0 0 {name=l268 lab=_073_}
N 2240 1160 2260 1160 {}
C {devices/lab_pin.sym} 2260 1160 0 0 {name=l269 lab=VDD}
N 2270 1200 2290 1200 {}
C {devices/lab_pin.sym} 2290 1200 0 0 {name=l270 lab=_026_}
N 2240 1240 2260 1240 {}
C {devices/lab_pin.sym} 2260 1240 0 0 {name=l271 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2550 1200 0 0 {name=_389_}
N 2530 1180 2510 1180 {}
C {devices/lab_pin.sym} 2510 1180 0 0 {name=l272 lab=tx_data[4]}
N 2530 1220 2510 1220 {}
C {devices/lab_pin.sym} 2510 1220 0 0 {name=l273 lab=txreg[4]}
N 2570 1240 2570 1260 {}
C {devices/lab_pin.sym} 2570 1260 0 0 {name=l274 lab=_073_}
N 2590 1160 2610 1160 {}
C {devices/lab_pin.sym} 2610 1160 0 0 {name=l275 lab=VDD}
N 2620 1200 2640 1200 {}
C {devices/lab_pin.sym} 2640 1200 0 0 {name=l276 lab=_027_}
N 2590 1240 2610 1240 {}
C {devices/lab_pin.sym} 2610 1240 0 0 {name=l277 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2900 1200 0 0 {name=_390_}
N 2880 1180 2860 1180 {}
C {devices/lab_pin.sym} 2860 1180 0 0 {name=l278 lab=tx_data[3]}
N 2880 1220 2860 1220 {}
C {devices/lab_pin.sym} 2860 1220 0 0 {name=l279 lab=txreg[3]}
N 2920 1240 2920 1260 {}
C {devices/lab_pin.sym} 2920 1260 0 0 {name=l280 lab=_073_}
N 2940 1160 2960 1160 {}
C {devices/lab_pin.sym} 2960 1160 0 0 {name=l281 lab=VDD}
N 2970 1200 2990 1200 {}
C {devices/lab_pin.sym} 2990 1200 0 0 {name=l282 lab=_028_}
N 2940 1240 2960 1240 {}
C {devices/lab_pin.sym} 2960 1240 0 0 {name=l283 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3250 1200 0 0 {name=_391_}
N 3230 1180 3210 1180 {}
C {devices/lab_pin.sym} 3210 1180 0 0 {name=l284 lab=tx_data[2]}
N 3230 1220 3210 1220 {}
C {devices/lab_pin.sym} 3210 1220 0 0 {name=l285 lab=txreg[2]}
N 3270 1240 3270 1260 {}
C {devices/lab_pin.sym} 3270 1260 0 0 {name=l286 lab=_073_}
N 3290 1160 3310 1160 {}
C {devices/lab_pin.sym} 3310 1160 0 0 {name=l287 lab=VDD}
N 3320 1200 3340 1200 {}
C {devices/lab_pin.sym} 3340 1200 0 0 {name=l288 lab=_029_}
N 3290 1240 3310 1240 {}
C {devices/lab_pin.sym} 3310 1240 0 0 {name=l289 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3600 1200 0 0 {name=_392_}
N 3580 1180 3560 1180 {}
C {devices/lab_pin.sym} 3560 1180 0 0 {name=l290 lab=tx_data[1]}
N 3580 1220 3560 1220 {}
C {devices/lab_pin.sym} 3560 1220 0 0 {name=l291 lab=txreg[1]}
N 3620 1240 3620 1260 {}
C {devices/lab_pin.sym} 3620 1260 0 0 {name=l292 lab=_073_}
N 3640 1160 3660 1160 {}
C {devices/lab_pin.sym} 3660 1160 0 0 {name=l293 lab=VDD}
N 3670 1200 3690 1200 {}
C {devices/lab_pin.sym} 3690 1200 0 0 {name=l294 lab=_030_}
N 3640 1240 3660 1240 {}
C {devices/lab_pin.sym} 3660 1240 0 0 {name=l295 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3950 1200 0 0 {name=_393_}
N 3930 1180 3910 1180 {}
C {devices/lab_pin.sym} 3910 1180 0 0 {name=l296 lab=tx_data[0]}
N 3930 1220 3910 1220 {}
C {devices/lab_pin.sym} 3910 1220 0 0 {name=l297 lab=txreg[0]}
N 3970 1240 3970 1260 {}
C {devices/lab_pin.sym} 3970 1260 0 0 {name=l298 lab=_073_}
N 3990 1160 4010 1160 {}
C {devices/lab_pin.sym} 4010 1160 0 0 {name=l299 lab=VDD}
N 4020 1200 4040 1200 {}
C {devices/lab_pin.sym} 4040 1200 0 0 {name=l300 lab=_031_}
N 3990 1240 4010 1240 {}
C {devices/lab_pin.sym} 4010 1240 0 0 {name=l301 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4300 1200 0 0 {name=_394_}
N 4330 1140 4330 1120 {}
C {devices/lab_pin.sym} 4330 1120 0 0 {name=l302 lab=VDD}
N 4410 1200 4430 1200 {}
C {devices/lab_pin.sym} 4430 1200 0 0 {name=l303 lab=_074_}
N 4280 1180 4260 1180 {}
C {devices/lab_pin.sym} 4260 1180 0 0 {name=l304 lab=phase[1]}
N 4280 1220 4260 1220 {}
C {devices/lab_pin.sym} 4260 1220 0 0 {name=l305 lab=_058_}
N 4330 1260 4330 1280 {}
C {devices/lab_pin.sym} 4330 1280 0 0 {name=l306 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4650 1200 0 0 {name=_395_}
N 4680 1140 4680 1120 {}
C {devices/lab_pin.sym} 4680 1120 0 0 {name=l307 lab=VDD}
N 4780 1200 4800 1200 {}
C {devices/lab_pin.sym} 4800 1200 0 0 {name=l308 lab=_075_}
N 4630 1180 4610 1180 {}
C {devices/lab_pin.sym} 4610 1180 0 0 {name=l309 lab=addr_match}
N 4630 1220 4610 1220 {}
C {devices/lab_pin.sym} 4610 1220 0 0 {name=l310 lab=_114_}
N 4680 1260 4680 1280 {}
C {devices/lab_pin.sym} 4680 1280 0 0 {name=l311 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 800 1500 0 0 {name=_396_}
N 830 1440 830 1420 {}
C {devices/lab_pin.sym} 830 1420 0 0 {name=l312 lab=VDD}
N 910 1500 930 1500 {}
C {devices/lab_pin.sym} 930 1500 0 0 {name=l313 lab=_076_}
N 780 1480 760 1480 {}
C {devices/lab_pin.sym} 760 1480 0 0 {name=l314 lab=_052_}
N 780 1520 760 1520 {}
C {devices/lab_pin.sym} 760 1520 0 0 {name=l315 lab=_075_}
N 830 1560 830 1580 {}
C {devices/lab_pin.sym} 830 1580 0 0 {name=l316 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1150 1500 0 0 {name=_397_}
N 1180 1440 1180 1420 {}
C {devices/lab_pin.sym} 1180 1420 0 0 {name=l317 lab=VDD}
N 1280 1500 1300 1500 {}
C {devices/lab_pin.sym} 1300 1500 0 0 {name=l318 lab=_077_}
N 1130 1480 1110 1480 {}
C {devices/lab_pin.sym} 1110 1480 0 0 {name=l319 lab=sda_in_buf1}
N 1130 1520 1110 1520 {}
C {devices/lab_pin.sym} 1110 1520 0 0 {name=l320 lab=_051_}
N 1180 1560 1180 1580 {}
C {devices/lab_pin.sym} 1180 1580 0 0 {name=l321 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1500 1500 0 0 {name=_398_}
N 1530 1440 1530 1420 {}
C {devices/lab_pin.sym} 1530 1420 0 0 {name=l322 lab=VDD}
N 1630 1500 1650 1500 {}
C {devices/lab_pin.sym} 1650 1500 0 0 {name=l323 lab=_078_}
N 1480 1480 1460 1480 {}
C {devices/lab_pin.sym} 1460 1480 0 0 {name=l324 lab=_070_}
N 1480 1520 1460 1520 {}
C {devices/lab_pin.sym} 1460 1520 0 0 {name=l325 lab=_077_}
N 1530 1560 1530 1580 {}
C {devices/lab_pin.sym} 1530 1580 0 0 {name=l326 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1850 1500 0 0 {name=_399_}
N 1880 1440 1880 1420 {}
C {devices/lab_pin.sym} 1880 1420 0 0 {name=l327 lab=VDD}
N 1980 1500 2000 1500 {}
C {devices/lab_pin.sym} 2000 1500 0 0 {name=l328 lab=_079_}
N 1830 1480 1810 1480 {}
C {devices/lab_pin.sym} 1810 1480 0 0 {name=l329 lab=_054_}
N 1830 1520 1810 1520 {}
C {devices/lab_pin.sym} 1810 1520 0 0 {name=l330 lab=_058_}
N 1880 1560 1880 1580 {}
C {devices/lab_pin.sym} 1880 1580 0 0 {name=l331 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 2200 1500 0 0 {name=_400_}
N 2190 1470 2190 1450 {}
C {devices/lab_pin.sym} 2190 1450 0 0 {name=l332 lab=rx_valid}
N 2190 1490 2170 1490 {}
C {devices/lab_pin.sym} 2170 1490 0 0 {name=l333 lab=_076_}
N 2190 1510 2170 1510 {}
C {devices/lab_pin.sym} 2170 1510 0 0 {name=l334 lab=_078_}
N 2190 1530 2190 1550 {}
C {devices/lab_pin.sym} 2190 1550 0 0 {name=l335 lab=_079_}
N 2230 1440 2230 1420 {}
C {devices/lab_pin.sym} 2230 1420 0 0 {name=l336 lab=VDD}
N 2310 1500 2330 1500 {}
C {devices/lab_pin.sym} 2330 1500 0 0 {name=l337 lab=_080_}
N 2230 1560 2230 1580 {}
C {devices/lab_pin.sym} 2230 1580 0 0 {name=l338 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2550 1500 0 0 {name=_401_}
N 2580 1440 2580 1420 {}
C {devices/lab_pin.sym} 2580 1420 0 0 {name=l339 lab=VDD}
N 2660 1500 2680 1500 {}
C {devices/lab_pin.sym} 2680 1500 0 0 {name=l340 lab=_032_}
N 2530 1480 2510 1480 {}
C {devices/lab_pin.sym} 2510 1480 0 0 {name=l341 lab=_074_}
N 2530 1520 2510 1520 {}
C {devices/lab_pin.sym} 2510 1520 0 0 {name=l342 lab=_080_}
N 2580 1560 2580 1580 {}
C {devices/lab_pin.sym} 2580 1580 0 0 {name=l343 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 2900 1500 0 0 {name=_402_}
N 2930 1440 2930 1420 {}
C {devices/lab_pin.sym} 2930 1420 0 0 {name=l344 lab=VDD}
N 3010 1500 3030 1500 {}
C {devices/lab_pin.sym} 3030 1500 0 0 {name=l345 lab=_033_}
N 2880 1480 2860 1480 {}
C {devices/lab_pin.sym} 2860 1480 0 0 {name=l346 lab=_049_}
N 2880 1520 2860 1520 {}
C {devices/lab_pin.sym} 2860 1520 0 0 {name=l347 lab=_057_}
N 2930 1560 2930 1580 {}
C {devices/lab_pin.sym} 2930 1580 0 0 {name=l348 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3250 1500 0 0 {name=_403_}
N 3280 1440 3280 1420 {}
C {devices/lab_pin.sym} 3280 1420 0 0 {name=l349 lab=VDD}
N 3360 1500 3380 1500 {}
C {devices/lab_pin.sym} 3380 1500 0 0 {name=l350 lab=_081_}
N 3230 1480 3210 1480 {}
C {devices/lab_pin.sym} 3210 1480 0 0 {name=l351 lab=phase[2]}
N 3230 1520 3210 1520 {}
C {devices/lab_pin.sym} 3210 1520 0 0 {name=l352 lab=_058_}
N 3280 1560 3280 1580 {}
C {devices/lab_pin.sym} 3280 1580 0 0 {name=l353 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3600 1500 0 0 {name=_404_}
N 3630 1440 3630 1420 {}
C {devices/lab_pin.sym} 3630 1420 0 0 {name=l354 lab=VDD}
N 3730 1500 3750 1500 {}
C {devices/lab_pin.sym} 3750 1500 0 0 {name=l355 lab=_082_}
N 3580 1480 3560 1480 {}
C {devices/lab_pin.sym} 3560 1480 0 0 {name=l356 lab=addr_match}
N 3580 1520 3560 1520 {}
C {devices/lab_pin.sym} 3560 1520 0 0 {name=l357 lab=_115_}
N 3630 1560 3630 1580 {}
C {devices/lab_pin.sym} 3630 1580 0 0 {name=l358 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3950 1500 0 0 {name=_405_}
N 3980 1440 3980 1420 {}
C {devices/lab_pin.sym} 3980 1420 0 0 {name=l359 lab=VDD}
N 4060 1500 4080 1500 {}
C {devices/lab_pin.sym} 4080 1500 0 0 {name=l360 lab=_083_}
N 3930 1480 3910 1480 {}
C {devices/lab_pin.sym} 3910 1480 0 0 {name=l361 lab=_052_}
N 3930 1520 3910 1520 {}
C {devices/lab_pin.sym} 3910 1520 0 0 {name=l362 lab=_082_}
N 3980 1560 3980 1580 {}
C {devices/lab_pin.sym} 3980 1580 0 0 {name=l363 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 4300 1500 0 0 {name=_406_}
N 4290 1470 4290 1450 {}
C {devices/lab_pin.sym} 4290 1450 0 0 {name=l364 lab=_046_}
N 4290 1490 4270 1490 {}
C {devices/lab_pin.sym} 4270 1490 0 0 {name=l365 lab=_051_}
N 4290 1510 4270 1510 {}
C {devices/lab_pin.sym} 4270 1510 0 0 {name=l366 lab=_079_}
N 4290 1530 4290 1550 {}
C {devices/lab_pin.sym} 4290 1550 0 0 {name=l367 lab=_083_}
N 4330 1440 4330 1420 {}
C {devices/lab_pin.sym} 4330 1420 0 0 {name=l368 lab=VDD}
N 4410 1500 4430 1500 {}
C {devices/lab_pin.sym} 4430 1500 0 0 {name=l369 lab=_084_}
N 4330 1560 4330 1580 {}
C {devices/lab_pin.sym} 4330 1580 0 0 {name=l370 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4650 1500 0 0 {name=_407_}
N 4680 1440 4680 1420 {}
C {devices/lab_pin.sym} 4680 1420 0 0 {name=l371 lab=VDD}
N 4760 1500 4780 1500 {}
C {devices/lab_pin.sym} 4780 1500 0 0 {name=l372 lab=_034_}
N 4630 1480 4610 1480 {}
C {devices/lab_pin.sym} 4610 1480 0 0 {name=l373 lab=_081_}
N 4630 1520 4610 1520 {}
C {devices/lab_pin.sym} 4610 1520 0 0 {name=l374 lab=_084_}
N 4680 1560 4680 1580 {}
C {devices/lab_pin.sym} 4680 1580 0 0 {name=l375 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 800 1800 0 0 {name=_408_}
N 830 1740 830 1720 {}
C {devices/lab_pin.sym} 830 1720 0 0 {name=l376 lab=VDD}
N 930 1800 950 1800 {}
C {devices/lab_pin.sym} 950 1800 0 0 {name=l377 lab=_085_}
N 780 1780 760 1780 {}
C {devices/lab_pin.sym} 760 1780 0 0 {name=l378 lab=_121_}
N 780 1820 760 1820 {}
C {devices/lab_pin.sym} 760 1820 0 0 {name=l379 lab=_057_}
N 830 1860 830 1880 {}
C {devices/lab_pin.sym} 830 1880 0 0 {name=l380 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 1150 1800 0 0 {name=_409_}
N 1130 1780 1110 1780 {}
C {devices/lab_pin.sym} 1110 1780 0 0 {name=l381 lab=sda_in_buf0}
N 1130 1820 1110 1820 {}
C {devices/lab_pin.sym} 1110 1820 0 0 {name=l382 lab=rw}
N 1170 1840 1170 1860 {}
C {devices/lab_pin.sym} 1170 1860 0 0 {name=l383 lab=_085_}
N 1190 1760 1210 1760 {}
C {devices/lab_pin.sym} 1210 1760 0 0 {name=l384 lab=VDD}
N 1220 1800 1240 1800 {}
C {devices/lab_pin.sym} 1240 1800 0 0 {name=l385 lab=_035_}
N 1190 1840 1210 1840 {}
C {devices/lab_pin.sym} 1210 1840 0 0 {name=l386 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1500 1800 0 0 {name=_410_}
N 1530 1740 1530 1720 {}
C {devices/lab_pin.sym} 1530 1720 0 0 {name=l387 lab=VDD}
N 1610 1800 1630 1800 {}
C {devices/lab_pin.sym} 1630 1800 0 0 {name=l388 lab=_086_}
N 1480 1780 1460 1780 {}
C {devices/lab_pin.sym} 1460 1780 0 0 {name=l389 lab=tx_data[7]}
N 1480 1820 1460 1820 {}
C {devices/lab_pin.sym} 1460 1820 0 0 {name=l390 lab=_073_}
N 1530 1860 1530 1880 {}
C {devices/lab_pin.sym} 1530 1880 0 0 {name=l391 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 1850 1800 0 0 {name=_411_}
N 1830 1780 1810 1780 {}
C {devices/lab_pin.sym} 1810 1780 0 0 {name=l392 lab=tx_data[7]}
N 1830 1820 1810 1820 {}
C {devices/lab_pin.sym} 1810 1820 0 0 {name=l393 lab=txreg[7]}
N 1870 1840 1870 1860 {}
C {devices/lab_pin.sym} 1870 1860 0 0 {name=l394 lab=_073_}
N 1890 1760 1910 1760 {}
C {devices/lab_pin.sym} 1910 1760 0 0 {name=l395 lab=VDD}
N 1920 1800 1940 1800 {}
C {devices/lab_pin.sym} 1940 1800 0 0 {name=l396 lab=_036_}
N 1890 1840 1910 1840 {}
C {devices/lab_pin.sym} 1910 1840 0 0 {name=l397 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2200 1800 0 0 {name=_412_}
N 2180 1780 2160 1780 {}
C {devices/lab_pin.sym} 2160 1780 0 0 {name=l398 lab=shreg[6]}
N 2180 1820 2160 1820 {}
C {devices/lab_pin.sym} 2160 1820 0 0 {name=l399 lab=rx_data[7]}
N 2220 1840 2220 1860 {}
C {devices/lab_pin.sym} 2220 1860 0 0 {name=l400 lab=_070_}
N 2240 1760 2260 1760 {}
C {devices/lab_pin.sym} 2260 1760 0 0 {name=l401 lab=VDD}
N 2270 1800 2290 1800 {}
C {devices/lab_pin.sym} 2290 1800 0 0 {name=l402 lab=_037_}
N 2240 1840 2260 1840 {}
C {devices/lab_pin.sym} 2260 1840 0 0 {name=l403 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2550 1800 0 0 {name=_413_}
N 2530 1820 2510 1820 {}
C {devices/lab_pin.sym} 2510 1820 0 0 {name=l404 lab=txreg[6]}
N 2580 1740 2580 1720 {}
C {devices/lab_pin.sym} 2580 1720 0 0 {name=l405 lab=VDD}
N 2680 1800 2700 1800 {}
C {devices/lab_pin.sym} 2700 1800 0 0 {name=l406 lab=_087_}
N 2530 1780 2510 1780 {}
C {devices/lab_pin.sym} 2510 1780 0 0 {name=l407 lab=bit_cnt[0]}
N 2530 1800 2510 1800 {}
C {devices/lab_pin.sym} 2510 1800 0 0 {name=l408 lab=_111_}
N 2580 1860 2580 1880 {}
C {devices/lab_pin.sym} 2580 1880 0 0 {name=l409 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2900 1800 0 0 {name=_414_}
N 2930 1740 2930 1720 {}
C {devices/lab_pin.sym} 2930 1720 0 0 {name=l410 lab=VDD}
N 3030 1800 3050 1800 {}
C {devices/lab_pin.sym} 3050 1800 0 0 {name=l411 lab=_088_}
N 2880 1780 2860 1780 {}
C {devices/lab_pin.sym} 2860 1780 0 0 {name=l412 lab=txreg[7]}
N 2880 1820 2860 1820 {}
C {devices/lab_pin.sym} 2860 1820 0 0 {name=l413 lab=_066_}
N 2930 1860 2930 1880 {}
C {devices/lab_pin.sym} 2930 1880 0 0 {name=l414 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3250 1800 0 0 {name=_415_}
N 3280 1740 3280 1720 {}
C {devices/lab_pin.sym} 3280 1720 0 0 {name=l415 lab=VDD}
N 3380 1800 3400 1800 {}
C {devices/lab_pin.sym} 3400 1800 0 0 {name=l416 lab=_089_}
N 3230 1780 3210 1780 {}
C {devices/lab_pin.sym} 3210 1780 0 0 {name=l417 lab=txreg[4]}
N 3230 1820 3210 1820 {}
C {devices/lab_pin.sym} 3210 1820 0 0 {name=l418 lab=_055_}
N 3280 1860 3280 1880 {}
C {devices/lab_pin.sym} 3280 1880 0 0 {name=l419 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 3600 1800 0 0 {name=_416_}
N 3580 1820 3560 1820 {}
C {devices/lab_pin.sym} 3560 1820 0 0 {name=l420 lab=txreg[5]}
N 3630 1740 3630 1720 {}
C {devices/lab_pin.sym} 3630 1720 0 0 {name=l421 lab=VDD}
N 3730 1800 3750 1800 {}
C {devices/lab_pin.sym} 3750 1800 0 0 {name=l422 lab=_090_}
N 3580 1780 3560 1780 {}
C {devices/lab_pin.sym} 3560 1780 0 0 {name=l423 lab=_110_}
N 3580 1800 3560 1800 {}
C {devices/lab_pin.sym} 3560 1800 0 0 {name=l424 lab=bit_cnt[1]}
N 3630 1860 3630 1880 {}
C {devices/lab_pin.sym} 3630 1880 0 0 {name=l425 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND4.sym} 3950 1800 0 0 {name=_417_}
N 3930 1770 3930 1750 {}
C {devices/lab_pin.sym} 3930 1750 0 0 {name=l426 lab=_087_}
N 3930 1790 3910 1790 {}
C {devices/lab_pin.sym} 3910 1790 0 0 {name=l427 lab=_088_}
N 3930 1810 3910 1810 {}
C {devices/lab_pin.sym} 3910 1810 0 0 {name=l428 lab=_090_}
N 3930 1830 3930 1850 {}
C {devices/lab_pin.sym} 3930 1850 0 0 {name=l429 lab=_089_}
N 3980 1740 3980 1720 {}
C {devices/lab_pin.sym} 3980 1720 0 0 {name=l430 lab=VDD}
N 4080 1800 4100 1800 {}
C {devices/lab_pin.sym} 4100 1800 0 0 {name=l431 lab=_091_}
N 3980 1860 3980 1880 {}
C {devices/lab_pin.sym} 3980 1880 0 0 {name=l432 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4300 1800 0 0 {name=_418_}
N 4330 1740 4330 1720 {}
C {devices/lab_pin.sym} 4330 1720 0 0 {name=l433 lab=VDD}
N 4430 1800 4450 1800 {}
C {devices/lab_pin.sym} 4450 1800 0 0 {name=l434 lab=_092_}
N 4280 1780 4260 1780 {}
C {devices/lab_pin.sym} 4260 1780 0 0 {name=l435 lab=_011_}
N 4280 1820 4260 1820 {}
C {devices/lab_pin.sym} 4260 1820 0 0 {name=l436 lab=_091_}
N 4330 1860 4330 1880 {}
C {devices/lab_pin.sym} 4330 1880 0 0 {name=l437 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4650 1800 0 0 {name=_419_}
N 4680 1740 4680 1720 {}
C {devices/lab_pin.sym} 4680 1720 0 0 {name=l438 lab=VDD}
N 4780 1800 4800 1800 {}
C {devices/lab_pin.sym} 4800 1800 0 0 {name=l439 lab=_093_}
N 4630 1780 4610 1780 {}
C {devices/lab_pin.sym} 4610 1780 0 0 {name=l440 lab=_112_}
N 4630 1820 4610 1820 {}
C {devices/lab_pin.sym} 4610 1820 0 0 {name=l441 lab=_092_}
N 4680 1860 4680 1880 {}
C {devices/lab_pin.sym} 4680 1880 0 0 {name=l442 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 800 2100 0 0 {name=_420_}
N 830 2040 830 2020 {}
C {devices/lab_pin.sym} 830 2020 0 0 {name=l443 lab=VDD}
N 930 2100 950 2100 {}
C {devices/lab_pin.sym} 950 2100 0 0 {name=l444 lab=_094_}
N 780 2080 760 2080 {}
C {devices/lab_pin.sym} 760 2080 0 0 {name=l445 lab=txreg[3]}
N 780 2120 760 2120 {}
C {devices/lab_pin.sym} 760 2120 0 0 {name=l446 lab=_066_}
N 830 2160 830 2180 {}
C {devices/lab_pin.sym} 830 2180 0 0 {name=l447 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 1150 2100 0 0 {name=_421_}
N 1130 2120 1110 2120 {}
C {devices/lab_pin.sym} 1110 2120 0 0 {name=l448 lab=txreg[2]}
N 1180 2040 1180 2020 {}
C {devices/lab_pin.sym} 1180 2020 0 0 {name=l449 lab=VDD}
N 1280 2100 1300 2100 {}
C {devices/lab_pin.sym} 1300 2100 0 0 {name=l450 lab=_095_}
N 1130 2080 1110 2080 {}
C {devices/lab_pin.sym} 1110 2080 0 0 {name=l451 lab=bit_cnt[0]}
N 1130 2100 1110 2100 {}
C {devices/lab_pin.sym} 1110 2100 0 0 {name=l452 lab=_111_}
N 1180 2160 1180 2180 {}
C {devices/lab_pin.sym} 1180 2180 0 0 {name=l453 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 1500 2100 0 0 {name=_422_}
N 1480 2120 1460 2120 {}
C {devices/lab_pin.sym} 1460 2120 0 0 {name=l454 lab=txreg[1]}
N 1530 2040 1530 2020 {}
C {devices/lab_pin.sym} 1530 2020 0 0 {name=l455 lab=VDD}
N 1630 2100 1650 2100 {}
C {devices/lab_pin.sym} 1650 2100 0 0 {name=l456 lab=_096_}
N 1480 2080 1460 2080 {}
C {devices/lab_pin.sym} 1460 2080 0 0 {name=l457 lab=_110_}
N 1480 2100 1460 2100 {}
C {devices/lab_pin.sym} 1460 2100 0 0 {name=l458 lab=bit_cnt[1]}
N 1530 2160 1530 2180 {}
C {devices/lab_pin.sym} 1530 2180 0 0 {name=l459 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1850 2100 0 0 {name=_423_}
N 1880 2040 1880 2020 {}
C {devices/lab_pin.sym} 1880 2020 0 0 {name=l460 lab=VDD}
N 1980 2100 2000 2100 {}
C {devices/lab_pin.sym} 2000 2100 0 0 {name=l461 lab=_097_}
N 1830 2080 1810 2080 {}
C {devices/lab_pin.sym} 1810 2080 0 0 {name=l462 lab=txreg[0]}
N 1830 2120 1810 2120 {}
C {devices/lab_pin.sym} 1810 2120 0 0 {name=l463 lab=_055_}
N 1880 2160 1880 2180 {}
C {devices/lab_pin.sym} 1880 2180 0 0 {name=l464 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND4.sym} 2200 2100 0 0 {name=_424_}
N 2180 2070 2180 2050 {}
C {devices/lab_pin.sym} 2180 2050 0 0 {name=l465 lab=_094_}
N 2180 2090 2160 2090 {}
C {devices/lab_pin.sym} 2160 2090 0 0 {name=l466 lab=_095_}
N 2180 2110 2160 2110 {}
C {devices/lab_pin.sym} 2160 2110 0 0 {name=l467 lab=_097_}
N 2180 2130 2180 2150 {}
C {devices/lab_pin.sym} 2180 2150 0 0 {name=l468 lab=_096_}
N 2230 2040 2230 2020 {}
C {devices/lab_pin.sym} 2230 2020 0 0 {name=l469 lab=VDD}
N 2330 2100 2350 2100 {}
C {devices/lab_pin.sym} 2350 2100 0 0 {name=l470 lab=_098_}
N 2230 2160 2230 2180 {}
C {devices/lab_pin.sym} 2230 2180 0 0 {name=l471 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2550 2100 0 0 {name=_425_}
N 2580 2040 2580 2020 {}
C {devices/lab_pin.sym} 2580 2020 0 0 {name=l472 lab=VDD}
N 2660 2100 2680 2100 {}
C {devices/lab_pin.sym} 2680 2100 0 0 {name=l473 lab=_099_}
N 2530 2080 2510 2080 {}
C {devices/lab_pin.sym} 2510 2080 0 0 {name=l474 lab=_112_}
N 2530 2120 2510 2120 {}
C {devices/lab_pin.sym} 2510 2120 0 0 {name=l475 lab=_098_}
N 2580 2160 2580 2180 {}
C {devices/lab_pin.sym} 2580 2180 0 0 {name=l476 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 2900 2100 0 0 {name=_426_}
N 2880 2100 2860 2100 {}
C {devices/lab_pin.sym} 2860 2100 0 0 {name=l477 lab=_113_}
N 2880 2120 2860 2120 {}
C {devices/lab_pin.sym} 2860 2120 0 0 {name=l478 lab=_099_}
N 2930 2040 2930 2020 {}
C {devices/lab_pin.sym} 2930 2020 0 0 {name=l479 lab=VDD}
N 3010 2100 3030 2100 {}
C {devices/lab_pin.sym} 3030 2100 0 0 {name=l480 lab=_100_}
N 2880 2080 2860 2080 {}
C {devices/lab_pin.sym} 2860 2080 0 0 {name=l481 lab=bit_cnt[3]}
N 2930 2160 2930 2180 {}
C {devices/lab_pin.sym} 2930 2180 0 0 {name=l482 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3250 2100 0 0 {name=_427_}
N 3280 2040 3280 2020 {}
C {devices/lab_pin.sym} 3280 2020 0 0 {name=l483 lab=VDD}
N 3380 2100 3400 2100 {}
C {devices/lab_pin.sym} 3400 2100 0 0 {name=l484 lab=_101_}
N 3230 2080 3210 2080 {}
C {devices/lab_pin.sym} 3210 2080 0 0 {name=l485 lab=_093_}
N 3230 2120 3210 2120 {}
C {devices/lab_pin.sym} 3210 2120 0 0 {name=l486 lab=_100_}
N 3280 2160 3280 2180 {}
C {devices/lab_pin.sym} 3280 2180 0 0 {name=l487 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 3600 2100 0 0 {name=_428_}
N 3580 2120 3560 2120 {}
C {devices/lab_pin.sym} 3560 2120 0 0 {name=l488 lab=_101_}
N 3630 2040 3630 2020 {}
C {devices/lab_pin.sym} 3630 2020 0 0 {name=l489 lab=VDD}
N 3730 2100 3750 2100 {}
C {devices/lab_pin.sym} 3750 2100 0 0 {name=l490 lab=_102_}
N 3580 2080 3560 2080 {}
C {devices/lab_pin.sym} 3560 2080 0 0 {name=l491 lab=_046_}
N 3580 2100 3560 2100 {}
C {devices/lab_pin.sym} 3560 2100 0 0 {name=l492 lab=_072_}
N 3630 2160 3630 2180 {}
C {devices/lab_pin.sym} 3630 2180 0 0 {name=l493 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3950 2100 0 0 {name=_429_}
N 3980 2040 3980 2020 {}
C {devices/lab_pin.sym} 3980 2020 0 0 {name=l494 lab=VDD}
N 4060 2100 4080 2100 {}
C {devices/lab_pin.sym} 4080 2100 0 0 {name=l495 lab=_103_}
N 3930 2080 3910 2080 {}
C {devices/lab_pin.sym} 3910 2080 0 0 {name=l496 lab=addr_match}
N 3930 2120 3910 2120 {}
C {devices/lab_pin.sym} 3910 2120 0 0 {name=l497 lab=_052_}
N 3980 2160 3980 2180 {}
C {devices/lab_pin.sym} 3980 2180 0 0 {name=l498 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 4300 2100 0 0 {name=_430_}
N 4280 2100 4260 2100 {}
C {devices/lab_pin.sym} 4260 2100 0 0 {name=l499 lab=_086_}
N 4280 2120 4260 2120 {}
C {devices/lab_pin.sym} 4260 2120 0 0 {name=l500 lab=_103_}
N 4330 2040 4330 2020 {}
C {devices/lab_pin.sym} 4330 2020 0 0 {name=l501 lab=VDD}
N 4410 2100 4430 2100 {}
C {devices/lab_pin.sym} 4430 2100 0 0 {name=l502 lab=_104_}
N 4280 2080 4260 2080 {}
C {devices/lab_pin.sym} 4260 2080 0 0 {name=l503 lab=rx_valid}
N 4330 2160 4330 2180 {}
C {devices/lab_pin.sym} 4330 2180 0 0 {name=l504 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4650 2100 0 0 {name=_431_}
N 4680 2040 4680 2020 {}
C {devices/lab_pin.sym} 4680 2020 0 0 {name=l505 lab=VDD}
N 4780 2100 4800 2100 {}
C {devices/lab_pin.sym} 4800 2100 0 0 {name=l506 lab=_002_}
N 4630 2080 4610 2080 {}
C {devices/lab_pin.sym} 4610 2080 0 0 {name=l507 lab=_102_}
N 4630 2120 4610 2120 {}
C {devices/lab_pin.sym} 4610 2120 0 0 {name=l508 lab=_104_}
N 4680 2160 4680 2180 {}
C {devices/lab_pin.sym} 4680 2180 0 0 {name=l509 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 800 2400 0 0 {name=_432_}
N 830 2340 830 2320 {}
C {devices/lab_pin.sym} 830 2320 0 0 {name=l510 lab=VDD}
N 930 2400 950 2400 {}
C {devices/lab_pin.sym} 950 2400 0 0 {name=l511 lab=rst_sdaoe_domain}
N 780 2380 760 2380 {}
C {devices/lab_pin.sym} 760 2380 0 0 {name=l512 lab=busy}
N 780 2420 760 2420 {}
C {devices/lab_pin.sym} 760 2420 0 0 {name=l513 lab=rst_n}
N 830 2460 830 2480 {}
C {devices/lab_pin.sym} 830 2480 0 0 {name=l514 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1150 2400 0 0 {name=_433_}
N 1180 2340 1180 2320 {}
C {devices/lab_pin.sym} 1180 2320 0 0 {name=l515 lab=VDD}
N 1280 2400 1300 2400 {}
C {devices/lab_pin.sym} 1300 2400 0 0 {name=l516 lab=_105_}
N 1130 2380 1110 2380 {}
C {devices/lab_pin.sym} 1110 2380 0 0 {name=l517 lab=scl_buf0}
N 1130 2420 1110 2420 {}
C {devices/lab_pin.sym} 1110 2420 0 0 {name=l518 lab=sda_d}
N 1180 2460 1180 2480 {}
C {devices/lab_pin.sym} 1180 2480 0 0 {name=l519 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1500 2400 0 0 {name=_434_}
N 1530 2340 1530 2320 {}
C {devices/lab_pin.sym} 1530 2320 0 0 {name=l520 lab=VDD}
N 1610 2400 1630 2400 {}
C {devices/lab_pin.sym} 1630 2400 0 0 {name=l521 lab=start_pulse}
N 1480 2380 1460 2380 {}
C {devices/lab_pin.sym} 1460 2380 0 0 {name=l522 lab=sda_in_buf1}
N 1480 2420 1460 2420 {}
C {devices/lab_pin.sym} 1460 2420 0 0 {name=l523 lab=_105_}
N 1530 2460 1530 2480 {}
C {devices/lab_pin.sym} 1530 2480 0 0 {name=l524 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1850 2400 0 0 {name=_435_}
N 1880 2340 1880 2320 {}
C {devices/lab_pin.sym} 1880 2320 0 0 {name=l525 lab=VDD}
N 1960 2400 1980 2400 {}
C {devices/lab_pin.sym} 1980 2400 0 0 {name=l526 lab=rst_scl_domain}
N 1830 2380 1810 2380 {}
C {devices/lab_pin.sym} 1810 2380 0 0 {name=l527 lab=_116_}
N 1830 2420 1810 2420 {}
C {devices/lab_pin.sym} 1810 2420 0 0 {name=l528 lab=start_pulse}
N 1880 2460 1880 2480 {}
C {devices/lab_pin.sym} 1880 2480 0 0 {name=l529 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2200 2400 0 0 {name=_436_}
N 2230 2340 2230 2320 {}
C {devices/lab_pin.sym} 2230 2320 0 0 {name=l530 lab=VDD}
N 2310 2400 2330 2400 {}
C {devices/lab_pin.sym} 2330 2400 0 0 {name=l531 lab=_106_}
N 2180 2380 2160 2380 {}
C {devices/lab_pin.sym} 2160 2380 0 0 {name=l532 lab=_056_}
N 2180 2420 2160 2420 {}
C {devices/lab_pin.sym} 2160 2420 0 0 {name=l533 lab=_059_}
N 2230 2460 2230 2480 {}
C {devices/lab_pin.sym} 2230 2480 0 0 {name=l534 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2550 2400 0 0 {name=_437_}
N 2530 2380 2510 2380 {}
C {devices/lab_pin.sym} 2510 2380 0 0 {name=l535 lab=_106_}
N 2530 2420 2510 2420 {}
C {devices/lab_pin.sym} 2510 2420 0 0 {name=l536 lab=_062_}
N 2570 2440 2570 2460 {}
C {devices/lab_pin.sym} 2570 2460 0 0 {name=l537 lab=bit_cnt[3]}
N 2590 2360 2610 2360 {}
C {devices/lab_pin.sym} 2610 2360 0 0 {name=l538 lab=VDD}
N 2620 2400 2640 2400 {}
C {devices/lab_pin.sym} 2640 2400 0 0 {name=l539 lab=_038_}
N 2590 2440 2610 2440 {}
C {devices/lab_pin.sym} 2610 2440 0 0 {name=l540 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2900 2400 0 0 {name=_438_}
N 2880 2420 2860 2420 {}
C {devices/lab_pin.sym} 2860 2420 0 0 {name=l541 lab=_117_}
N 2930 2340 2930 2320 {}
C {devices/lab_pin.sym} 2930 2320 0 0 {name=l542 lab=VDD}
N 3030 2400 3050 2400 {}
C {devices/lab_pin.sym} 3050 2400 0 0 {name=l543 lab=_107_}
N 2880 2380 2860 2380 {}
C {devices/lab_pin.sym} 2860 2380 0 0 {name=l544 lab=sda_in_buf0}
N 2880 2400 2860 2400 {}
C {devices/lab_pin.sym} 2860 2400 0 0 {name=l545 lab=scl_buf1}
N 2930 2460 2930 2480 {}
C {devices/lab_pin.sym} 2930 2480 0 0 {name=l546 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3250 2400 0 0 {name=_439_}
N 3280 2340 3280 2320 {}
C {devices/lab_pin.sym} 3280 2320 0 0 {name=l547 lab=VDD}
N 3380 2400 3400 2400 {}
C {devices/lab_pin.sym} 3400 2400 0 0 {name=l548 lab=busy_clr}
N 3230 2380 3210 2380 {}
C {devices/lab_pin.sym} 3210 2380 0 0 {name=l549 lab=rst_n}
N 3230 2420 3210 2420 {}
C {devices/lab_pin.sym} 3210 2420 0 0 {name=l550 lab=_107_}
N 3280 2460 3280 2480 {}
C {devices/lab_pin.sym} 3280 2480 0 0 {name=l551 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR4.sym} 3600 2400 0 0 {name=_440_}
N 3590 2370 3590 2350 {}
C {devices/lab_pin.sym} 3590 2350 0 0 {name=l552 lab=_013_}
N 3590 2390 3570 2390 {}
C {devices/lab_pin.sym} 3570 2390 0 0 {name=l553 lab=_012_}
N 3590 2410 3570 2410 {}
C {devices/lab_pin.sym} 3570 2410 0 0 {name=l554 lab=shreg[5]}
N 3590 2430 3590 2450 {}
C {devices/lab_pin.sym} 3590 2450 0 0 {name=l555 lab=shreg[2]}
N 3630 2340 3630 2320 {}
C {devices/lab_pin.sym} 3630 2320 0 0 {name=l556 lab=VDD}
N 3710 2400 3730 2400 {}
C {devices/lab_pin.sym} 3730 2400 0 0 {name=l557 lab=_108_}
N 3630 2460 3630 2480 {}
C {devices/lab_pin.sym} 3630 2480 0 0 {name=l558 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 3950 2400 0 0 {name=_441_}
N 3940 2370 3940 2350 {}
C {devices/lab_pin.sym} 3940 2350 0 0 {name=l559 lab=shreg[3]}
N 3940 2390 3920 2390 {}
C {devices/lab_pin.sym} 3920 2390 0 0 {name=l560 lab=shreg[0]}
N 3940 2410 3920 2410 {}
C {devices/lab_pin.sym} 3920 2410 0 0 {name=l561 lab=shreg[1]}
N 3940 2430 3940 2450 {}
C {devices/lab_pin.sym} 3940 2450 0 0 {name=l562 lab=_108_}
N 3980 2340 3980 2320 {}
C {devices/lab_pin.sym} 3980 2320 0 0 {name=l563 lab=VDD}
N 4060 2400 4080 2400 {}
C {devices/lab_pin.sym} 4080 2400 0 0 {name=l564 lab=_109_}
N 3980 2460 3980 2480 {}
C {devices/lab_pin.sym} 3980 2480 0 0 {name=l565 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 4300 2400 0 0 {name=_442_}
N 4280 2380 4260 2380 {}
C {devices/lab_pin.sym} 4260 2380 0 0 {name=l566 lab=_109_}
N 4280 2420 4260 2420 {}
C {devices/lab_pin.sym} 4260 2420 0 0 {name=l567 lab=addr_match}
N 4320 2440 4320 2460 {}
C {devices/lab_pin.sym} 4320 2460 0 0 {name=l568 lab=_085_}
N 4340 2360 4360 2360 {}
C {devices/lab_pin.sym} 4360 2360 0 0 {name=l569 lab=VDD}
N 4370 2400 4390 2400 {}
C {devices/lab_pin.sym} 4390 2400 0 0 {name=l570 lab=_039_}
N 4340 2440 4360 2440 {}
C {devices/lab_pin.sym} 4360 2440 0 0 {name=l571 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4650 2400 0 0 {name=_443_}
N 4620 2340 4620 2320 {}
C {devices/lab_pin.sym} 4620 2320 0 0 {name=l572 lab=VDD}
N 4680 2410 4700 2410 {}
C {devices/lab_pin.sym} 4700 2410 0 0 {name=l573 lab=_014_}
N 4620 2370 4600 2370 {}
C {devices/lab_pin.sym} 4600 2370 0 0 {name=l574 lab=_033_}
N 4680 2370 4700 2370 {}
C {devices/lab_pin.sym} 4700 2370 0 0 {name=l575 lab=phase[0]}
N 4650 2440 4650 2460 {}
C {devices/lab_pin.sym} 4650 2460 0 0 {name=l576 lab=_126_buf0}
N 4620 2460 4620 2480 {}
C {devices/lab_pin.sym} 4620 2480 0 0 {name=l577 lab=GND}
N 4620 2410 4600 2410 {}
C {devices/lab_pin.sym} 4600 2410 0 0 {name=l578 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 800 2700 0 0 {name=_444_}
N 770 2640 770 2620 {}
C {devices/lab_pin.sym} 770 2620 0 0 {name=l579 lab=VDD}
N 830 2710 850 2710 {}
C {devices/lab_pin.sym} 850 2710 0 0 {name=l580 lab=_008_}
N 770 2670 750 2670 {}
C {devices/lab_pin.sym} 750 2670 0 0 {name=l581 lab=_032_}
N 830 2670 850 2670 {}
C {devices/lab_pin.sym} 850 2670 0 0 {name=l582 lab=phase[1]}
N 800 2740 800 2760 {}
C {devices/lab_pin.sym} 800 2760 0 0 {name=l583 lab=_126_buf1}
N 770 2760 770 2780 {}
C {devices/lab_pin.sym} 770 2780 0 0 {name=l584 lab=GND}
N 770 2710 750 2710 {}
C {devices/lab_pin.sym} 750 2710 0 0 {name=l585 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1150 2700 0 0 {name=_445_}
N 1120 2640 1120 2620 {}
C {devices/lab_pin.sym} 1120 2620 0 0 {name=l586 lab=VDD}
N 1180 2710 1200 2710 {}
C {devices/lab_pin.sym} 1200 2710 0 0 {name=l587 lab=_007_}
N 1120 2670 1100 2670 {}
C {devices/lab_pin.sym} 1100 2670 0 0 {name=l588 lab=_034_}
N 1180 2670 1200 2670 {}
C {devices/lab_pin.sym} 1200 2670 0 0 {name=l589 lab=phase[2]}
N 1150 2740 1150 2760 {}
C {devices/lab_pin.sym} 1150 2760 0 0 {name=l590 lab=_126_buf0}
N 1120 2760 1120 2780 {}
C {devices/lab_pin.sym} 1120 2780 0 0 {name=l591 lab=GND}
N 1120 2710 1100 2710 {}
C {devices/lab_pin.sym} 1100 2710 0 0 {name=l592 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1500 2700 0 0 {name=_446_}
N 1470 2640 1470 2620 {}
C {devices/lab_pin.sym} 1470 2620 0 0 {name=l593 lab=VDD}
N 1530 2710 1550 2710 {}
C {devices/lab_pin.sym} 1550 2710 0 0 {name=l594 lab=_006_}
N 1470 2670 1450 2670 {}
C {devices/lab_pin.sym} 1450 2670 0 0 {name=l595 lab=_035_}
N 1530 2670 1550 2670 {}
C {devices/lab_pin.sym} 1550 2670 0 0 {name=l596 lab=rw}
N 1500 2740 1500 2760 {}
C {devices/lab_pin.sym} 1500 2760 0 0 {name=l597 lab=_126_buf1}
N 1470 2760 1470 2780 {}
C {devices/lab_pin.sym} 1470 2780 0 0 {name=l598 lab=GND}
N 1470 2710 1450 2710 {}
C {devices/lab_pin.sym} 1450 2710 0 0 {name=l599 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1850 2700 0 0 {name=_447_}
N 1820 2640 1820 2620 {}
C {devices/lab_pin.sym} 1820 2620 0 0 {name=l600 lab=VDD}
N 1880 2710 1900 2710 {}
C {devices/lab_pin.sym} 1900 2710 0 0 {name=l601 lab=_176_}
N 1820 2670 1800 2670 {}
C {devices/lab_pin.sym} 1800 2670 0 0 {name=l602 lab=_031_}
N 1880 2670 1900 2670 {}
C {devices/lab_pin.sym} 1900 2670 0 0 {name=l603 lab=txreg[0]}
N 1850 2740 1850 2760 {}
C {devices/lab_pin.sym} 1850 2760 0 0 {name=l604 lab=_127_buf0}
N 1820 2760 1820 2780 {}
C {devices/lab_pin.sym} 1820 2780 0 0 {name=l605 lab=GND}
N 1820 2710 1800 2710 {}
C {devices/lab_pin.sym} 1800 2710 0 0 {name=l606 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2200 2700 0 0 {name=_448_}
N 2170 2640 2170 2620 {}
C {devices/lab_pin.sym} 2170 2620 0 0 {name=l607 lab=VDD}
N 2230 2710 2250 2710 {}
C {devices/lab_pin.sym} 2250 2710 0 0 {name=l608 lab=_177_}
N 2170 2670 2150 2670 {}
C {devices/lab_pin.sym} 2150 2670 0 0 {name=l609 lab=_030_}
N 2230 2670 2250 2670 {}
C {devices/lab_pin.sym} 2250 2670 0 0 {name=l610 lab=txreg[1]}
N 2200 2740 2200 2760 {}
C {devices/lab_pin.sym} 2200 2760 0 0 {name=l611 lab=_127_buf1}
N 2170 2760 2170 2780 {}
C {devices/lab_pin.sym} 2170 2780 0 0 {name=l612 lab=GND}
N 2170 2710 2150 2710 {}
C {devices/lab_pin.sym} 2150 2710 0 0 {name=l613 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2550 2700 0 0 {name=_449_}
N 2520 2640 2520 2620 {}
C {devices/lab_pin.sym} 2520 2620 0 0 {name=l614 lab=VDD}
N 2580 2710 2600 2710 {}
C {devices/lab_pin.sym} 2600 2710 0 0 {name=l615 lab=_178_}
N 2520 2670 2500 2670 {}
C {devices/lab_pin.sym} 2500 2670 0 0 {name=l616 lab=_029_}
N 2580 2670 2600 2670 {}
C {devices/lab_pin.sym} 2600 2670 0 0 {name=l617 lab=txreg[2]}
N 2550 2740 2550 2760 {}
C {devices/lab_pin.sym} 2550 2760 0 0 {name=l618 lab=_127_buf0}
N 2520 2760 2520 2780 {}
C {devices/lab_pin.sym} 2520 2780 0 0 {name=l619 lab=GND}
N 2520 2710 2500 2710 {}
C {devices/lab_pin.sym} 2500 2710 0 0 {name=l620 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2900 2700 0 0 {name=_450_}
N 2870 2640 2870 2620 {}
C {devices/lab_pin.sym} 2870 2620 0 0 {name=l621 lab=VDD}
N 2930 2710 2950 2710 {}
C {devices/lab_pin.sym} 2950 2710 0 0 {name=l622 lab=_179_}
N 2870 2670 2850 2670 {}
C {devices/lab_pin.sym} 2850 2670 0 0 {name=l623 lab=_028_}
N 2930 2670 2950 2670 {}
C {devices/lab_pin.sym} 2950 2670 0 0 {name=l624 lab=txreg[3]}
N 2900 2740 2900 2760 {}
C {devices/lab_pin.sym} 2900 2760 0 0 {name=l625 lab=_127_buf1}
N 2870 2760 2870 2780 {}
C {devices/lab_pin.sym} 2870 2780 0 0 {name=l626 lab=GND}
N 2870 2710 2850 2710 {}
C {devices/lab_pin.sym} 2850 2710 0 0 {name=l627 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3250 2700 0 0 {name=_451_}
N 3220 2640 3220 2620 {}
C {devices/lab_pin.sym} 3220 2620 0 0 {name=l628 lab=VDD}
N 3280 2710 3300 2710 {}
C {devices/lab_pin.sym} 3300 2710 0 0 {name=l629 lab=_180_}
N 3220 2670 3200 2670 {}
C {devices/lab_pin.sym} 3200 2670 0 0 {name=l630 lab=_027_}
N 3280 2670 3300 2670 {}
C {devices/lab_pin.sym} 3300 2670 0 0 {name=l631 lab=txreg[4]}
N 3250 2740 3250 2760 {}
C {devices/lab_pin.sym} 3250 2760 0 0 {name=l632 lab=_127_buf0}
N 3220 2760 3220 2780 {}
C {devices/lab_pin.sym} 3220 2780 0 0 {name=l633 lab=GND}
N 3220 2710 3200 2710 {}
C {devices/lab_pin.sym} 3200 2710 0 0 {name=l634 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3600 2700 0 0 {name=_452_}
N 3570 2640 3570 2620 {}
C {devices/lab_pin.sym} 3570 2620 0 0 {name=l635 lab=VDD}
N 3630 2710 3650 2710 {}
C {devices/lab_pin.sym} 3650 2710 0 0 {name=l636 lab=_181_}
N 3570 2670 3550 2670 {}
C {devices/lab_pin.sym} 3550 2670 0 0 {name=l637 lab=_026_}
N 3630 2670 3650 2670 {}
C {devices/lab_pin.sym} 3650 2670 0 0 {name=l638 lab=txreg[5]}
N 3600 2740 3600 2760 {}
C {devices/lab_pin.sym} 3600 2760 0 0 {name=l639 lab=_127_buf1}
N 3570 2760 3570 2780 {}
C {devices/lab_pin.sym} 3570 2780 0 0 {name=l640 lab=GND}
N 3570 2710 3550 2710 {}
C {devices/lab_pin.sym} 3550 2710 0 0 {name=l641 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3950 2700 0 0 {name=_453_}
N 3920 2640 3920 2620 {}
C {devices/lab_pin.sym} 3920 2620 0 0 {name=l642 lab=VDD}
N 3980 2710 4000 2710 {}
C {devices/lab_pin.sym} 4000 2710 0 0 {name=l643 lab=_182_}
N 3920 2670 3900 2670 {}
C {devices/lab_pin.sym} 3900 2670 0 0 {name=l644 lab=_025_}
N 3980 2670 4000 2670 {}
C {devices/lab_pin.sym} 4000 2670 0 0 {name=l645 lab=txreg[6]}
N 3950 2740 3950 2760 {}
C {devices/lab_pin.sym} 3950 2760 0 0 {name=l646 lab=_127_buf0}
N 3920 2760 3920 2780 {}
C {devices/lab_pin.sym} 3920 2780 0 0 {name=l647 lab=GND}
N 3920 2710 3900 2710 {}
C {devices/lab_pin.sym} 3900 2710 0 0 {name=l648 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4300 2700 0 0 {name=_454_}
N 4270 2640 4270 2620 {}
C {devices/lab_pin.sym} 4270 2620 0 0 {name=l649 lab=VDD}
N 4330 2710 4350 2710 {}
C {devices/lab_pin.sym} 4350 2710 0 0 {name=l650 lab=_198_}
N 4270 2670 4250 2670 {}
C {devices/lab_pin.sym} 4250 2670 0 0 {name=l651 lab=_036_}
N 4330 2670 4350 2670 {}
C {devices/lab_pin.sym} 4350 2670 0 0 {name=l652 lab=txreg[7]}
N 4300 2740 4300 2760 {}
C {devices/lab_pin.sym} 4300 2760 0 0 {name=l653 lab=_127_buf1}
N 4270 2760 4270 2780 {}
C {devices/lab_pin.sym} 4270 2780 0 0 {name=l654 lab=GND}
N 4270 2710 4250 2710 {}
C {devices/lab_pin.sym} 4250 2710 0 0 {name=l655 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4650 2700 0 0 {name=_455_}
N 4620 2640 4620 2620 {}
C {devices/lab_pin.sym} 4620 2620 0 0 {name=l656 lab=VDD}
N 4680 2710 4700 2710 {}
C {devices/lab_pin.sym} 4700 2710 0 0 {name=l657 lab=_183_}
N 4620 2670 4600 2670 {}
C {devices/lab_pin.sym} 4600 2670 0 0 {name=l658 lab=_024_}
N 4680 2670 4700 2670 {}
C {devices/lab_pin.sym} 4700 2670 0 0 {name=l659 lab=rx_data[0]}
N 4650 2740 4650 2760 {}
C {devices/lab_pin.sym} 4650 2760 0 0 {name=l660 lab=_126_buf0}
N 4620 2760 4620 2780 {}
C {devices/lab_pin.sym} 4620 2780 0 0 {name=l661 lab=GND}
N 4620 2710 4600 2710 {}
C {devices/lab_pin.sym} 4600 2710 0 0 {name=l662 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 800 3000 0 0 {name=_456_}
N 770 2940 770 2920 {}
C {devices/lab_pin.sym} 770 2920 0 0 {name=l663 lab=VDD}
N 830 3010 850 3010 {}
C {devices/lab_pin.sym} 850 3010 0 0 {name=l664 lab=_184_}
N 770 2970 750 2970 {}
C {devices/lab_pin.sym} 750 2970 0 0 {name=l665 lab=_023_}
N 830 2970 850 2970 {}
C {devices/lab_pin.sym} 850 2970 0 0 {name=l666 lab=rx_data[1]}
N 800 3040 800 3060 {}
C {devices/lab_pin.sym} 800 3060 0 0 {name=l667 lab=_126_buf1}
N 770 3060 770 3080 {}
C {devices/lab_pin.sym} 770 3080 0 0 {name=l668 lab=GND}
N 770 3010 750 3010 {}
C {devices/lab_pin.sym} 750 3010 0 0 {name=l669 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1150 3000 0 0 {name=_457_}
N 1120 2940 1120 2920 {}
C {devices/lab_pin.sym} 1120 2920 0 0 {name=l670 lab=VDD}
N 1180 3010 1200 3010 {}
C {devices/lab_pin.sym} 1200 3010 0 0 {name=l671 lab=_185_}
N 1120 2970 1100 2970 {}
C {devices/lab_pin.sym} 1100 2970 0 0 {name=l672 lab=_022_}
N 1180 2970 1200 2970 {}
C {devices/lab_pin.sym} 1200 2970 0 0 {name=l673 lab=rx_data[2]}
N 1150 3040 1150 3060 {}
C {devices/lab_pin.sym} 1150 3060 0 0 {name=l674 lab=_126_buf0}
N 1120 3060 1120 3080 {}
C {devices/lab_pin.sym} 1120 3080 0 0 {name=l675 lab=GND}
N 1120 3010 1100 3010 {}
C {devices/lab_pin.sym} 1100 3010 0 0 {name=l676 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1500 3000 0 0 {name=_458_}
N 1470 2940 1470 2920 {}
C {devices/lab_pin.sym} 1470 2920 0 0 {name=l677 lab=VDD}
N 1530 3010 1550 3010 {}
C {devices/lab_pin.sym} 1550 3010 0 0 {name=l678 lab=_186_}
N 1470 2970 1450 2970 {}
C {devices/lab_pin.sym} 1450 2970 0 0 {name=l679 lab=_021_}
N 1530 2970 1550 2970 {}
C {devices/lab_pin.sym} 1550 2970 0 0 {name=l680 lab=rx_data[3]}
N 1500 3040 1500 3060 {}
C {devices/lab_pin.sym} 1500 3060 0 0 {name=l681 lab=_126_buf1}
N 1470 3060 1470 3080 {}
C {devices/lab_pin.sym} 1470 3080 0 0 {name=l682 lab=GND}
N 1470 3010 1450 3010 {}
C {devices/lab_pin.sym} 1450 3010 0 0 {name=l683 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1850 3000 0 0 {name=_459_}
N 1820 2940 1820 2920 {}
C {devices/lab_pin.sym} 1820 2920 0 0 {name=l684 lab=VDD}
N 1880 3010 1900 3010 {}
C {devices/lab_pin.sym} 1900 3010 0 0 {name=l685 lab=_187_}
N 1820 2970 1800 2970 {}
C {devices/lab_pin.sym} 1800 2970 0 0 {name=l686 lab=_020_}
N 1880 2970 1900 2970 {}
C {devices/lab_pin.sym} 1900 2970 0 0 {name=l687 lab=rx_data[4]}
N 1850 3040 1850 3060 {}
C {devices/lab_pin.sym} 1850 3060 0 0 {name=l688 lab=_126_buf0}
N 1820 3060 1820 3080 {}
C {devices/lab_pin.sym} 1820 3080 0 0 {name=l689 lab=GND}
N 1820 3010 1800 3010 {}
C {devices/lab_pin.sym} 1800 3010 0 0 {name=l690 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2200 3000 0 0 {name=_460_}
N 2170 2940 2170 2920 {}
C {devices/lab_pin.sym} 2170 2920 0 0 {name=l691 lab=VDD}
N 2230 3010 2250 3010 {}
C {devices/lab_pin.sym} 2250 3010 0 0 {name=l692 lab=_188_}
N 2170 2970 2150 2970 {}
C {devices/lab_pin.sym} 2150 2970 0 0 {name=l693 lab=_019_}
N 2230 2970 2250 2970 {}
C {devices/lab_pin.sym} 2250 2970 0 0 {name=l694 lab=rx_data[5]}
N 2200 3040 2200 3060 {}
C {devices/lab_pin.sym} 2200 3060 0 0 {name=l695 lab=_126_buf1}
N 2170 3060 2170 3080 {}
C {devices/lab_pin.sym} 2170 3080 0 0 {name=l696 lab=GND}
N 2170 3010 2150 3010 {}
C {devices/lab_pin.sym} 2150 3010 0 0 {name=l697 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2550 3000 0 0 {name=_461_}
N 2520 2940 2520 2920 {}
C {devices/lab_pin.sym} 2520 2920 0 0 {name=l698 lab=VDD}
N 2580 3010 2600 3010 {}
C {devices/lab_pin.sym} 2600 3010 0 0 {name=l699 lab=_189_}
N 2520 2970 2500 2970 {}
C {devices/lab_pin.sym} 2500 2970 0 0 {name=l700 lab=_018_}
N 2580 2970 2600 2970 {}
C {devices/lab_pin.sym} 2600 2970 0 0 {name=l701 lab=rx_data[6]}
N 2550 3040 2550 3060 {}
C {devices/lab_pin.sym} 2550 3060 0 0 {name=l702 lab=_126_buf0}
N 2520 3060 2520 3080 {}
C {devices/lab_pin.sym} 2520 3080 0 0 {name=l703 lab=GND}
N 2520 3010 2500 3010 {}
C {devices/lab_pin.sym} 2500 3010 0 0 {name=l704 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2900 3000 0 0 {name=_462_}
N 2870 2940 2870 2920 {}
C {devices/lab_pin.sym} 2870 2920 0 0 {name=l705 lab=VDD}
N 2930 3010 2950 3010 {}
C {devices/lab_pin.sym} 2950 3010 0 0 {name=l706 lab=_199_}
N 2870 2970 2850 2970 {}
C {devices/lab_pin.sym} 2850 2970 0 0 {name=l707 lab=_037_}
N 2930 2970 2950 2970 {}
C {devices/lab_pin.sym} 2950 2970 0 0 {name=l708 lab=rx_data[7]}
N 2900 3040 2900 3060 {}
C {devices/lab_pin.sym} 2900 3060 0 0 {name=l709 lab=_126_buf1}
N 2870 3060 2870 3080 {}
C {devices/lab_pin.sym} 2870 3080 0 0 {name=l710 lab=GND}
N 2870 3010 2850 3010 {}
C {devices/lab_pin.sym} 2850 3010 0 0 {name=l711 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3250 3000 0 0 {name=_463_}
N 3220 2940 3220 2920 {}
C {devices/lab_pin.sym} 3220 2920 0 0 {name=l712 lab=VDD}
N 3280 3010 3300 3010 {}
C {devices/lab_pin.sym} 3300 3010 0 0 {name=l713 lab=_009_}
N 3220 2970 3200 2970 {}
C {devices/lab_pin.sym} 3200 2970 0 0 {name=l714 lab=_017_}
N 3280 2970 3300 2970 {}
C {devices/lab_pin.sym} 3300 2970 0 0 {name=l715 lab=bit_cnt[0]}
N 3250 3040 3250 3060 {}
C {devices/lab_pin.sym} 3250 3060 0 0 {name=l716 lab=_126_buf0}
N 3220 3060 3220 3080 {}
C {devices/lab_pin.sym} 3220 3080 0 0 {name=l717 lab=GND}
N 3220 3010 3200 3010 {}
C {devices/lab_pin.sym} 3200 3010 0 0 {name=l718 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3600 3000 0 0 {name=_464_}
N 3570 2940 3570 2920 {}
C {devices/lab_pin.sym} 3570 2920 0 0 {name=l719 lab=VDD}
N 3630 3010 3650 3010 {}
C {devices/lab_pin.sym} 3650 3010 0 0 {name=l720 lab=_010_}
N 3570 2970 3550 2970 {}
C {devices/lab_pin.sym} 3550 2970 0 0 {name=l721 lab=_016_}
N 3630 2970 3650 2970 {}
C {devices/lab_pin.sym} 3650 2970 0 0 {name=l722 lab=bit_cnt[1]}
N 3600 3040 3600 3060 {}
C {devices/lab_pin.sym} 3600 3060 0 0 {name=l723 lab=_126_buf1}
N 3570 3060 3570 3080 {}
C {devices/lab_pin.sym} 3570 3080 0 0 {name=l724 lab=GND}
N 3570 3010 3550 3010 {}
C {devices/lab_pin.sym} 3550 3010 0 0 {name=l725 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3950 3000 0 0 {name=_465_}
N 3920 2940 3920 2920 {}
C {devices/lab_pin.sym} 3920 2920 0 0 {name=l726 lab=VDD}
N 3980 3010 4000 3010 {}
C {devices/lab_pin.sym} 4000 3010 0 0 {name=l727 lab=_011_}
N 3920 2970 3900 2970 {}
C {devices/lab_pin.sym} 3900 2970 0 0 {name=l728 lab=_015_}
N 3980 2970 4000 2970 {}
C {devices/lab_pin.sym} 4000 2970 0 0 {name=l729 lab=bit_cnt[2]}
N 3950 3040 3950 3060 {}
C {devices/lab_pin.sym} 3950 3060 0 0 {name=l730 lab=_126_buf0}
N 3920 3060 3920 3080 {}
C {devices/lab_pin.sym} 3920 3080 0 0 {name=l731 lab=GND}
N 3920 3010 3900 3010 {}
C {devices/lab_pin.sym} 3900 3010 0 0 {name=l732 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4300 3000 0 0 {name=_466_}
N 4270 2940 4270 2920 {}
C {devices/lab_pin.sym} 4270 2920 0 0 {name=l733 lab=VDD}
N 4330 3010 4350 3010 {}
C {devices/lab_pin.sym} 4350 3010 0 0 {name=l734 lab=_005_}
N 4270 2970 4250 2970 {}
C {devices/lab_pin.sym} 4250 2970 0 0 {name=l735 lab=_038_}
N 4330 2970 4350 2970 {}
C {devices/lab_pin.sym} 4350 2970 0 0 {name=l736 lab=bit_cnt[3]}
N 4300 3040 4300 3060 {}
C {devices/lab_pin.sym} 4300 3060 0 0 {name=l737 lab=_126_buf1}
N 4270 3060 4270 3080 {}
C {devices/lab_pin.sym} 4270 3080 0 0 {name=l738 lab=GND}
N 4270 3010 4250 3010 {}
C {devices/lab_pin.sym} 4250 3010 0 0 {name=l739 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4650 3000 0 0 {name=_467_}
N 4620 2940 4620 2920 {}
C {devices/lab_pin.sym} 4620 2920 0 0 {name=l740 lab=VDD}
N 4680 3010 4700 3010 {}
C {devices/lab_pin.sym} 4700 3010 0 0 {name=l741 lab=_168_}
N 4620 2970 4600 2970 {}
C {devices/lab_pin.sym} 4600 2970 0 0 {name=l742 lab=_039_}
N 4680 2970 4700 2970 {}
C {devices/lab_pin.sym} 4700 2970 0 0 {name=l743 lab=addr_match}
N 4650 3040 4650 3060 {}
C {devices/lab_pin.sym} 4650 3060 0 0 {name=l744 lab=_126_buf0}
N 4620 3060 4620 3080 {}
C {devices/lab_pin.sym} 4620 3080 0 0 {name=l745 lab=GND}
N 4620 3010 4600 3010 {}
C {devices/lab_pin.sym} 4600 3010 0 0 {name=l746 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 800 3300 0 0 {name=_468_}
N 770 3240 770 3220 {}
C {devices/lab_pin.sym} 770 3220 0 0 {name=l747 lab=VDD}
N 830 3310 850 3310 {}
C {devices/lab_pin.sym} 850 3310 0 0 {name=l748 lab=_171_}
N 770 3270 750 3270 {}
C {devices/lab_pin.sym} 750 3270 0 0 {name=l749 lab=_002_}
N 830 3270 850 3270 {}
C {devices/lab_pin.sym} 850 3270 0 0 {name=l750 lab=sda_oe}
N 800 3340 800 3360 {}
C {devices/lab_pin.sym} 800 3360 0 0 {name=l751 lab=_127_buf0}
N 770 3360 770 3380 {}
C {devices/lab_pin.sym} 770 3380 0 0 {name=l752 lab=GND}
N 770 3310 750 3310 {}
C {devices/lab_pin.sym} 750 3310 0 0 {name=l753 lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1150 3300 0 0 {name=_469_}
N 1120 3240 1120 3220 {}
C {devices/lab_pin.sym} 1120 3220 0 0 {name=l754 lab=VDD}
N 1180 3310 1200 3310 {}
C {devices/lab_pin.sym} 1200 3310 0 0 {name=l755 lab=_170_}
N 1120 3270 1100 3270 {}
C {devices/lab_pin.sym} 1100 3270 0 0 {name=l756 lab=sda_in_buf1}
N 1180 3270 1200 3270 {}
C {devices/lab_pin.sym} 1200 3270 0 0 {name=l757 lab=shreg[0]}
N 1150 3340 1150 3360 {}
C {devices/lab_pin.sym} 1150 3360 0 0 {name=l758 lab=_126_buf1}
N 1120 3360 1120 3380 {}
C {devices/lab_pin.sym} 1120 3380 0 0 {name=l759 lab=GND}
N 1120 3310 1100 3310 {}
C {devices/lab_pin.sym} 1100 3310 0 0 {name=l760 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1500 3300 0 0 {name=_470_}
N 1470 3240 1470 3220 {}
C {devices/lab_pin.sym} 1470 3220 0 0 {name=l761 lab=VDD}
N 1530 3310 1550 3310 {}
C {devices/lab_pin.sym} 1550 3310 0 0 {name=l762 lab=_167_}
N 1470 3270 1450 3270 {}
C {devices/lab_pin.sym} 1450 3270 0 0 {name=l763 lab=shreg[0]}
N 1530 3270 1550 3270 {}
C {devices/lab_pin.sym} 1550 3270 0 0 {name=l764 lab=shreg[1]}
N 1500 3340 1500 3360 {}
C {devices/lab_pin.sym} 1500 3360 0 0 {name=l765 lab=_126_buf0}
N 1470 3360 1470 3380 {}
C {devices/lab_pin.sym} 1470 3380 0 0 {name=l766 lab=GND}
N 1470 3310 1450 3310 {}
C {devices/lab_pin.sym} 1450 3310 0 0 {name=l767 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1850 3300 0 0 {name=_471_}
N 1820 3240 1820 3220 {}
C {devices/lab_pin.sym} 1820 3220 0 0 {name=l768 lab=VDD}
N 1880 3310 1900 3310 {}
C {devices/lab_pin.sym} 1900 3310 0 0 {name=l769 lab=_174_}
N 1820 3270 1800 3270 {}
C {devices/lab_pin.sym} 1800 3270 0 0 {name=l770 lab=shreg[1]}
N 1880 3270 1900 3270 {}
C {devices/lab_pin.sym} 1900 3270 0 0 {name=l771 lab=shreg[2]}
N 1850 3340 1850 3360 {}
C {devices/lab_pin.sym} 1850 3360 0 0 {name=l772 lab=_126_buf1}
N 1820 3360 1820 3380 {}
C {devices/lab_pin.sym} 1820 3380 0 0 {name=l773 lab=GND}
N 1820 3310 1800 3310 {}
C {devices/lab_pin.sym} 1800 3310 0 0 {name=l774 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2200 3300 0 0 {name=_472_}
N 2170 3240 2170 3220 {}
C {devices/lab_pin.sym} 2170 3220 0 0 {name=l775 lab=VDD}
N 2230 3310 2250 3310 {}
C {devices/lab_pin.sym} 2250 3310 0 0 {name=l776 lab=_197_}
N 2170 3270 2150 3270 {}
C {devices/lab_pin.sym} 2150 3270 0 0 {name=l777 lab=shreg[2]}
N 2230 3270 2250 3270 {}
C {devices/lab_pin.sym} 2250 3270 0 0 {name=l778 lab=shreg[3]}
N 2200 3340 2200 3360 {}
C {devices/lab_pin.sym} 2200 3360 0 0 {name=l779 lab=_126_buf0}
N 2170 3360 2170 3380 {}
C {devices/lab_pin.sym} 2170 3380 0 0 {name=l780 lab=GND}
N 2170 3310 2150 3310 {}
C {devices/lab_pin.sym} 2150 3310 0 0 {name=l781 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2550 3300 0 0 {name=_473_}
N 2520 3240 2520 3220 {}
C {devices/lab_pin.sym} 2520 3220 0 0 {name=l782 lab=VDD}
N 2580 3310 2600 3310 {}
C {devices/lab_pin.sym} 2600 3310 0 0 {name=l783 lab=_012_}
N 2520 3270 2500 3270 {}
C {devices/lab_pin.sym} 2500 3270 0 0 {name=l784 lab=shreg[3]}
N 2580 3270 2600 3270 {}
C {devices/lab_pin.sym} 2600 3270 0 0 {name=l785 lab=shreg[4]}
N 2550 3340 2550 3360 {}
C {devices/lab_pin.sym} 2550 3360 0 0 {name=l786 lab=_126_buf1}
N 2520 3360 2520 3380 {}
C {devices/lab_pin.sym} 2520 3380 0 0 {name=l787 lab=GND}
N 2520 3310 2500 3310 {}
C {devices/lab_pin.sym} 2500 3310 0 0 {name=l788 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2900 3300 0 0 {name=_474_}
N 2870 3240 2870 3220 {}
C {devices/lab_pin.sym} 2870 3220 0 0 {name=l789 lab=VDD}
N 2930 3310 2950 3310 {}
C {devices/lab_pin.sym} 2950 3310 0 0 {name=l790 lab=_194_}
N 2870 3270 2850 3270 {}
C {devices/lab_pin.sym} 2850 3270 0 0 {name=l791 lab=shreg[4]}
N 2930 3270 2950 3270 {}
C {devices/lab_pin.sym} 2950 3270 0 0 {name=l792 lab=shreg[5]}
N 2900 3340 2900 3360 {}
C {devices/lab_pin.sym} 2900 3360 0 0 {name=l793 lab=_126_buf0}
N 2870 3360 2870 3380 {}
C {devices/lab_pin.sym} 2870 3380 0 0 {name=l794 lab=GND}
N 2870 3310 2850 3310 {}
C {devices/lab_pin.sym} 2850 3310 0 0 {name=l795 lab=scl_buf0}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3250 3300 0 0 {name=_475_}
N 3220 3240 3220 3220 {}
C {devices/lab_pin.sym} 3220 3220 0 0 {name=l796 lab=VDD}
N 3280 3310 3300 3310 {}
C {devices/lab_pin.sym} 3300 3310 0 0 {name=l797 lab=_013_}
N 3220 3270 3200 3270 {}
C {devices/lab_pin.sym} 3200 3270 0 0 {name=l798 lab=shreg[5]}
N 3280 3270 3300 3270 {}
C {devices/lab_pin.sym} 3300 3270 0 0 {name=l799 lab=shreg[6]}
N 3250 3340 3250 3360 {}
C {devices/lab_pin.sym} 3250 3360 0 0 {name=l800 lab=_126_buf1}
N 3220 3360 3220 3380 {}
C {devices/lab_pin.sym} 3220 3380 0 0 {name=l801 lab=GND}
N 3220 3310 3200 3310 {}
C {devices/lab_pin.sym} 3200 3310 0 0 {name=l802 lab=scl_buf1}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DEL1.sym} 3600 3300 0 0 {name=u_del_sda}
N 3630 3260 3630 3240 {}
C {devices/lab_pin.sym} 3630 3240 0 0 {name=l803 lab=VDD}
N 3580 3300 3560 3300 {}
C {devices/lab_pin.sym} 3560 3300 0 0 {name=l804 lab=sda_in_buf0}
N 3700 3300 3720 3300 {}
C {devices/lab_pin.sym} 3720 3300 0 0 {name=l805 lab=sda_d}
N 3630 3340 3630 3360 {}
C {devices/lab_pin.sym} 3630 3360 0 0 {name=l806 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3950 3300 0 0 {name=u_inv_scl}
N 3980 3260 3980 3240 {}
C {devices/lab_pin.sym} 3980 3240 0 0 {name=l807 lab=VDD}
N 3930 3300 3910 3300 {}
C {devices/lab_pin.sym} 3910 3300 0 0 {name=l808 lab=scl_buf0}
N 4050 3300 4070 3300 {}
C {devices/lab_pin.sym} 4070 3300 0 0 {name=l809 lab=scl_n}
N 3980 3340 3980 3360 {}
C {devices/lab_pin.sym} 3980 3360 0 0 {name=l810 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4300 3300 0 0 {name=u_lat_q}
N 4330 3240 4330 3220 {}
C {devices/lab_pin.sym} 4330 3220 0 0 {name=l811 lab=VDD}
N 4410 3300 4430 3300 {}
C {devices/lab_pin.sym} 4430 3300 0 0 {name=l812 lab=busy}
N 4280 3280 4260 3280 {}
C {devices/lab_pin.sym} 4260 3280 0 0 {name=l813 lab=busy_clr}
N 4280 3320 4260 3320 {}
C {devices/lab_pin.sym} 4260 3320 0 0 {name=l814 lab=qn}
N 4330 3360 4330 3380 {}
C {devices/lab_pin.sym} 4330 3380 0 0 {name=l815 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4650 3300 0 0 {name=u_lat_qn}
N 4680 3240 4680 3220 {}
C {devices/lab_pin.sym} 4680 3220 0 0 {name=l816 lab=VDD}
N 4760 3300 4780 3300 {}
C {devices/lab_pin.sym} 4780 3300 0 0 {name=l817 lab=qn}
N 4630 3280 4610 3280 {}
C {devices/lab_pin.sym} 4610 3280 0 0 {name=l818 lab=start_pulse}
N 4630 3320 4610 3320 {}
C {devices/lab_pin.sym} 4610 3320 0 0 {name=l819 lab=busy}
N 4680 3360 4680 3380 {}
C {devices/lab_pin.sym} 4680 3380 0 0 {name=l820 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X16.sym} 800 3600 0 0 {name=u_scl_buf0}
N 830 3560 830 3540 {}
C {devices/lab_pin.sym} 830 3540 0 0 {name=l821 lab=VDD}
N 780 3600 760 3600 {}
C {devices/lab_pin.sym} 760 3600 0 0 {name=l822 lab=scl}
N 900 3600 920 3600 {}
C {devices/lab_pin.sym} 920 3600 0 0 {name=l823 lab=scl_buf0}
N 830 3640 830 3660 {}
C {devices/lab_pin.sym} 830 3660 0 0 {name=l824 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X16.sym} 1150 3600 0 0 {name=u_scl_buf1}
N 1180 3560 1180 3540 {}
C {devices/lab_pin.sym} 1180 3540 0 0 {name=l825 lab=VDD}
N 1130 3600 1110 3600 {}
C {devices/lab_pin.sym} 1110 3600 0 0 {name=l826 lab=scl}
N 1250 3600 1270 3600 {}
C {devices/lab_pin.sym} 1270 3600 0 0 {name=l827 lab=scl_buf1}
N 1180 3640 1180 3660 {}
C {devices/lab_pin.sym} 1180 3660 0 0 {name=l828 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X2.sym} 1500 3600 0 0 {name=u_sda_in_buf0}
N 1530 3560 1530 3540 {}
C {devices/lab_pin.sym} 1530 3540 0 0 {name=l829 lab=VDD}
N 1480 3600 1460 3600 {}
C {devices/lab_pin.sym} 1460 3600 0 0 {name=l830 lab=sda_in}
N 1600 3600 1620 3600 {}
C {devices/lab_pin.sym} 1620 3600 0 0 {name=l831 lab=sda_in_buf0}
N 1530 3640 1530 3660 {}
C {devices/lab_pin.sym} 1530 3660 0 0 {name=l832 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X2.sym} 1850 3600 0 0 {name=u_sda_in_buf1}
N 1880 3560 1880 3540 {}
C {devices/lab_pin.sym} 1880 3540 0 0 {name=l833 lab=VDD}
N 1830 3600 1810 3600 {}
C {devices/lab_pin.sym} 1810 3600 0 0 {name=l834 lab=sda_in}
N 1950 3600 1970 3600 {}
C {devices/lab_pin.sym} 1970 3600 0 0 {name=l835 lab=sda_in_buf1}
N 1880 3640 1880 3660 {}
C {devices/lab_pin.sym} 1880 3660 0 0 {name=l836 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X4.sym} 2200 3600 0 0 {name=u__126_buf0}
N 2230 3560 2230 3540 {}
C {devices/lab_pin.sym} 2230 3540 0 0 {name=l837 lab=VDD}
N 2180 3600 2160 3600 {}
C {devices/lab_pin.sym} 2160 3600 0 0 {name=l838 lab=rst_scl_domain}
N 2300 3600 2320 3600 {}
C {devices/lab_pin.sym} 2320 3600 0 0 {name=l839 lab=_126_buf0}
N 2230 3640 2230 3660 {}
C {devices/lab_pin.sym} 2230 3660 0 0 {name=l840 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X4.sym} 2550 3600 0 0 {name=u__126_buf1}
N 2580 3560 2580 3540 {}
C {devices/lab_pin.sym} 2580 3540 0 0 {name=l841 lab=VDD}
N 2530 3600 2510 3600 {}
C {devices/lab_pin.sym} 2510 3600 0 0 {name=l842 lab=rst_scl_domain}
N 2650 3600 2670 3600 {}
C {devices/lab_pin.sym} 2670 3600 0 0 {name=l843 lab=_126_buf1}
N 2580 3640 2580 3660 {}
C {devices/lab_pin.sym} 2580 3660 0 0 {name=l844 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X2.sym} 2900 3600 0 0 {name=u__127_buf0}
N 2930 3560 2930 3540 {}
C {devices/lab_pin.sym} 2930 3540 0 0 {name=l845 lab=VDD}
N 2880 3600 2860 3600 {}
C {devices/lab_pin.sym} 2860 3600 0 0 {name=l846 lab=rst_sdaoe_domain}
N 3000 3600 3020 3600 {}
C {devices/lab_pin.sym} 3020 3600 0 0 {name=l847 lab=_127_buf0}
N 2930 3640 2930 3660 {}
C {devices/lab_pin.sym} 2930 3660 0 0 {name=l848 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X2.sym} 3250 3600 0 0 {name=u__127_buf1}
N 3280 3560 3280 3540 {}
C {devices/lab_pin.sym} 3280 3540 0 0 {name=l849 lab=VDD}
N 3230 3600 3210 3600 {}
C {devices/lab_pin.sym} 3210 3600 0 0 {name=l850 lab=rst_sdaoe_domain}
N 3350 3600 3370 3600 {}
C {devices/lab_pin.sym} 3370 3600 0 0 {name=l851 lab=_127_buf1}
N 3280 3640 3280 3660 {}
C {devices/lab_pin.sym} 3280 3660 0 0 {name=l852 lab=GND}
C {devices/iopin.sym} 0 -200 0 0 {name=io_VDD lab=VDD}
C {devices/iopin.sym} 0 -140 0 0 {name=io_GND lab=GND}
C {devices/ipin.sym} 0 -80 0 0 {name=io_rst_n lab=rst_n}
C {devices/ipin.sym} 0 -20 0 0 {name=io_scl lab=scl}
C {devices/ipin.sym} 0 40 0 0 {name=io_sda_in lab=sda_in}
C {devices/ipin.sym} 0 100 0 0 {name=io_tx_data_7_ lab=tx_data[7]}
C {devices/ipin.sym} 0 160 0 0 {name=io_tx_data_6_ lab=tx_data[6]}
C {devices/ipin.sym} 0 220 0 0 {name=io_tx_data_5_ lab=tx_data[5]}
C {devices/ipin.sym} 0 280 0 0 {name=io_tx_data_4_ lab=tx_data[4]}
C {devices/ipin.sym} 0 340 0 0 {name=io_tx_data_3_ lab=tx_data[3]}
C {devices/ipin.sym} 0 400 0 0 {name=io_tx_data_2_ lab=tx_data[2]}
C {devices/ipin.sym} 0 460 0 0 {name=io_tx_data_1_ lab=tx_data[1]}
C {devices/ipin.sym} 0 520 0 0 {name=io_tx_data_0_ lab=tx_data[0]}
C {devices/opin.sym} 5200 -200 0 0 {name=io_sda_oe lab=sda_oe}
C {devices/opin.sym} 5200 -140 0 0 {name=io_rx_data_7_ lab=rx_data[7]}
C {devices/opin.sym} 5200 -80 0 0 {name=io_rx_data_6_ lab=rx_data[6]}
C {devices/opin.sym} 5200 -20 0 0 {name=io_rx_data_5_ lab=rx_data[5]}
C {devices/opin.sym} 5200 40 0 0 {name=io_rx_data_4_ lab=rx_data[4]}
C {devices/opin.sym} 5200 100 0 0 {name=io_rx_data_3_ lab=rx_data[3]}
C {devices/opin.sym} 5200 160 0 0 {name=io_rx_data_2_ lab=rx_data[2]}
C {devices/opin.sym} 5200 220 0 0 {name=io_rx_data_1_ lab=rx_data[1]}
C {devices/opin.sym} 5200 280 0 0 {name=io_rx_data_0_ lab=rx_data[0]}
C {devices/opin.sym} 5200 340 0 0 {name=io_rx_valid lab=rx_valid}
C {devices/opin.sym} 5200 400 0 0 {name=io_addr_match lab=addr_match}
C {devices/opin.sym} 5200 460 0 0 {name=io_rw lab=rw}
C {devices/opin.sym} 5200 520 0 0 {name=io_busy lab=busy}
