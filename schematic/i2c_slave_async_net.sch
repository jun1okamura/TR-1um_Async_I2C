v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 800 0 0 0 {name=_336_}
N 830 -40 830 -60 {
lab=VDD}
N 780 0 760 0 {
lab=bit_cnt[0]}
N 900 0 920 0 {
lab=_110_}
N 830 40 830 60 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1150 0 0 0 {name=_337_}
N 1180 -40 1180 -60 {
lab=VDD}
N 1130 0 1110 0 {
lab=bit_cnt[1]}
N 1250 0 1270 0 {
lab=_111_}
N 1180 40 1180 60 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1500 0 0 0 {name=_338_}
N 1530 -40 1530 -60 {
lab=VDD}
N 1480 0 1460 0 {
lab=bit_cnt[2]}
N 1600 0 1620 0 {
lab=_112_}
N 1530 40 1530 60 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1850 0 0 0 {name=_339_}
N 1880 -40 1880 -60 {
lab=VDD}
N 1830 0 1810 0 {
lab=_005_}
N 1950 0 1970 0 {
lab=_113_}
N 1880 40 1880 60 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2200 0 0 0 {name=_340_}
N 2230 -40 2230 -60 {
lab=VDD}
N 2180 0 2160 0 {
lab=_006_}
N 2300 0 2320 0 {
lab=_114_}
N 2230 40 2230 60 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2550 0 0 0 {name=_341_}
N 2580 -40 2580 -60 {
lab=VDD}
N 2530 0 2510 0 {
lab=rw}
N 2650 0 2670 0 {
lab=_115_}
N 2580 40 2580 60 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2900 0 0 0 {name=_342_}
N 2930 -40 2930 -60 {
lab=VDD}
N 2880 0 2860 0 {
lab=rst_n}
N 3000 0 3020 0 {
lab=_116_}
N 2930 40 2930 60 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3250 0 0 0 {name=_343_}
N 3280 -40 3280 -60 {
lab=VDD}
N 3230 0 3210 0 {
lab=sda_d}
N 3350 0 3370 0 {
lab=_117_}
N 3280 40 3280 60 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 3600 0 0 0 {name=_344_}
N 3630 -60 3630 -80 {
lab=VDD}
N 3710 0 3730 0 {
lab=_118_}
N 3580 -20 3560 -20 {
lab=phase[2]}
N 3580 20 3560 20 {
lab=_008_}
N 3630 60 3630 80 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3950 0 0 0 {name=_345_}
N 3980 -60 3980 -80 {
lab=VDD}
N 4060 0 4080 0 {
lab=rx_valid}
N 3930 -20 3910 -20 {
lab=_014_}
N 3930 20 3910 20 {
lab=_118_}
N 3980 60 3980 80 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4300 0 0 0 {name=_346_}
N 4330 -60 4330 -80 {
lab=VDD}
N 4410 0 4430 0 {
lab=_119_}
N 4280 -20 4260 -20 {
lab=phase[0]}
N 4280 20 4260 20 {
lab=_118_}
N 4330 60 4330 80 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 4650 0 0 0 {name=_347_}
N 4680 -60 4680 -80 {
lab=VDD}
N 4760 0 4780 0 {
lab=_120_}
N 4630 -20 4610 -20 {
lab=phase[1]}
N 4630 20 4610 20 {
lab=phase[0]}
N 4680 60 4680 80 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 800 300 0 0 {name=_348_}
N 830 240 830 220 {
lab=VDD}
N 910 300 930 300 {
lab=_121_}
N 780 280 760 280 {
lab=phase[2]}
N 780 320 760 320 {
lab=_120_}
N 830 360 830 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1150 300 0 0 {name=_349_}
N 1180 240 1180 220 {
lab=VDD}
N 1260 300 1280 300 {
lab=_046_}
N 1130 280 1110 280 {
lab=_007_}
N 1130 320 1110 320 {
lab=_120_}
N 1180 360 1180 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1500 300 0 0 {name=_350_}
N 1530 260 1530 240 {
lab=VDD}
N 1480 300 1460 300 {
lab=_046_}
N 1600 300 1620 300 {
lab=_047_}
N 1530 340 1530 360 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 1850 300 0 0 {name=_351_}
N 1830 300 1810 300 {
lab=_121_}
N 1830 320 1810 320 {
lab=_046_}
N 1880 240 1880 220 {
lab=VDD}
N 1960 300 1980 300 {
lab=_048_}
N 1830 280 1810 280 {
lab=_119_}
N 1880 360 1880 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR3.sym} 2200 300 0 0 {name=_352_}
N 2180 320 2160 320 {
lab=_046_}
N 2230 240 2230 220 {
lab=VDD}
N 2310 300 2330 300 {
lab=_049_}
N 2180 280 2160 280 {
lab=_119_}
N 2180 300 2160 300 {
lab=_121_}
N 2230 360 2230 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 2550 300 0 0 {name=_353_}
N 2580 240 2580 220 {
lab=VDD}
N 2660 300 2680 300 {
lab=_050_}
N 2530 280 2510 280 {
lab=_014_}
N 2530 320 2510 320 {
lab=phase[1]}
N 2580 360 2580 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2900 300 0 0 {name=_354_}
N 2930 240 2930 220 {
lab=VDD}
N 3010 300 3030 300 {
lab=_051_}
N 2880 280 2860 280 {
lab=_007_}
N 2880 320 2860 320 {
lab=_050_}
N 2930 360 2930 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3250 300 0 0 {name=_355_}
N 3280 240 3280 220 {
lab=VDD}
N 3360 300 3380 300 {
lab=_052_}
N 3230 280 3210 280 {
lab=phase[2]}
N 3230 320 3210 320 {
lab=_050_}
N 3280 360 3280 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 3600 300 0 0 {name=_356_}
N 3590 270 3590 250 {
lab=rx_valid}
N 3590 290 3570 290 {
lab=_049_}
N 3590 310 3570 310 {
lab=_051_}
N 3590 330 3590 350 {
lab=_052_}
N 3630 240 3630 220 {
lab=VDD}
N 3710 300 3730 300 {
lab=_053_}
N 3630 360 3630 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3950 300 0 0 {name=_357_}
N 3980 260 3980 240 {
lab=VDD}
N 3930 300 3910 300 {
lab=_053_}
N 4050 300 4070 300 {
lab=_054_}
N 3980 340 3980 360 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 4300 300 0 0 {name=_358_}
N 4330 240 4330 220 {
lab=VDD}
N 4410 300 4430 300 {
lab=_055_}
N 4280 280 4260 280 {
lab=bit_cnt[0]}
N 4280 320 4260 320 {
lab=bit_cnt[1]}
N 4330 360 4330 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4650 300 0 0 {name=_359_}
N 4680 240 4680 220 {
lab=VDD}
N 4780 300 4800 300 {
lab=_056_}
N 4630 280 4610 280 {
lab=bit_cnt[2]}
N 4630 320 4610 320 {
lab=_055_}
N 4680 360 4680 380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 800 600 0 0 {name=_360_}
N 790 570 790 550 {
lab=bit_cnt[3]}
N 790 590 770 590 {
lab=_009_}
N 790 610 770 610 {
lab=_011_}
N 790 630 790 650 {
lab=_010_}
N 830 540 830 520 {
lab=VDD}
N 910 600 930 600 {
lab=_057_}
N 830 660 830 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1150 600 0 0 {name=_361_}
N 1180 540 1180 520 {
lab=VDD}
N 1260 600 1280 600 {
lab=_058_}
N 1130 580 1110 580 {
lab=_048_}
N 1130 620 1110 620 {
lab=_057_}
N 1180 660 1180 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 1500 600 0 0 {name=_362_}
N 1530 540 1530 520 {
lab=VDD}
N 1610 600 1630 600 {
lab=_059_}
N 1480 580 1460 580 {
lab=_047_}
N 1480 620 1460 620 {
lab=_058_}
N 1530 660 1530 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1850 600 0 0 {name=_363_}
N 1880 540 1880 520 {
lab=VDD}
N 1980 600 2000 600 {
lab=_060_}
N 1830 580 1810 580 {
lab=_047_}
N 1830 620 1810 620 {
lab=_058_}
N 1880 660 1880 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2200 600 0 0 {name=_364_}
N 2230 540 2230 520 {
lab=VDD}
N 2330 600 2350 600 {
lab=_061_}
N 2180 580 2160 580 {
lab=_056_}
N 2180 620 2160 620 {
lab=_060_}
N 2230 660 2230 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2550 600 0 0 {name=_365_}
N 2580 540 2580 520 {
lab=VDD}
N 2680 600 2700 600 {
lab=_062_}
N 2530 580 2510 580 {
lab=_054_}
N 2530 620 2510 620 {
lab=_061_}
N 2580 660 2580 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2900 600 0 0 {name=_366_}
N 2930 540 2930 520 {
lab=VDD}
N 3030 600 3050 600 {
lab=_063_}
N 2880 580 2860 580 {
lab=_055_}
N 2880 620 2860 620 {
lab=_060_}
N 2930 660 2930 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3250 600 0 0 {name=_367_}
N 3280 540 3280 520 {
lab=VDD}
N 3380 600 3400 600 {
lab=_064_}
N 3230 580 3210 580 {
lab=_112_}
N 3230 620 3210 620 {
lab=_063_}
N 3280 660 3280 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3600 600 0 0 {name=_368_}
N 3630 540 3630 520 {
lab=VDD}
N 3710 600 3730 600 {
lab=_015_}
N 3580 580 3560 580 {
lab=_062_}
N 3580 620 3560 620 {
lab=_064_}
N 3630 660 3630 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3950 600 0 0 {name=_369_}
N 3980 540 3980 520 {
lab=VDD}
N 4080 600 4100 600 {
lab=_065_}
N 3930 580 3910 580 {
lab=bit_cnt[1]}
N 3930 620 3910 620 {
lab=_053_}
N 3980 660 3980 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4300 600 0 0 {name=_370_}
N 4330 540 4330 520 {
lab=VDD}
N 4410 600 4430 600 {
lab=_066_}
N 4280 580 4260 580 {
lab=bit_cnt[0]}
N 4280 620 4260 620 {
lab=bit_cnt[1]}
N 4330 660 4330 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR3.sym} 4650 600 0 0 {name=_371_}
N 4630 620 4610 620 {
lab=_066_}
N 4680 540 4680 520 {
lab=VDD}
N 4760 600 4780 600 {
lab=_067_}
N 4630 580 4610 580 {
lab=_055_}
N 4630 600 4610 600 {
lab=_059_}
N 4680 660 4680 680 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 800 900 0 0 {name=_372_}
N 830 840 830 820 {
lab=VDD}
N 930 900 950 900 {
lab=_016_}
N 780 880 760 880 {
lab=_065_}
N 780 920 760 920 {
lab=_067_}
N 830 960 830 980 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1150 900 0 0 {name=_373_}
N 1180 840 1180 820 {
lab=VDD}
N 1280 900 1300 900 {
lab=_068_}
N 1130 880 1110 880 {
lab=bit_cnt[0]}
N 1130 920 1110 920 {
lab=_053_}
N 1180 960 1180 980 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1500 900 0 0 {name=_374_}
N 1530 840 1530 820 {
lab=VDD}
N 1630 900 1650 900 {
lab=_069_}
N 1480 880 1460 880 {
lab=_009_}
N 1480 920 1460 920 {
lab=_049_}
N 1530 960 1530 980 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1850 900 0 0 {name=_375_}
N 1880 840 1880 820 {
lab=VDD}
N 1980 900 2000 900 {
lab=_017_}
N 1830 880 1810 880 {
lab=_068_}
N 1830 920 1810 920 {
lab=_069_}
N 1880 960 1880 980 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2200 900 0 0 {name=_376_}
N 2230 840 2230 820 {
lab=VDD}
N 2330 900 2350 900 {
lab=_070_}
N 2180 880 2160 880 {
lab=_119_}
N 2180 920 2160 920 {
lab=_057_}
N 2230 960 2230 980 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2550 900 0 0 {name=_377_}
N 2530 880 2510 880 {
lab=shreg[5]}
N 2530 920 2510 920 {
lab=rx_data[6]}
N 2570 940 2570 960 {
lab=_070_}
N 2590 860 2610 860 {
lab=VDD}
N 2620 900 2640 900 {
lab=_018_}
N 2590 940 2610 940 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2900 900 0 0 {name=_378_}
N 2880 880 2860 880 {
lab=shreg[4]}
N 2880 920 2860 920 {
lab=rx_data[5]}
N 2920 940 2920 960 {
lab=_070_}
N 2940 860 2960 860 {
lab=VDD}
N 2970 900 2990 900 {
lab=_019_}
N 2940 940 2960 940 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3250 900 0 0 {name=_379_}
N 3230 880 3210 880 {
lab=shreg[3]}
N 3230 920 3210 920 {
lab=rx_data[4]}
N 3270 940 3270 960 {
lab=_070_}
N 3290 860 3310 860 {
lab=VDD}
N 3320 900 3340 900 {
lab=_020_}
N 3290 940 3310 940 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3600 900 0 0 {name=_380_}
N 3580 880 3560 880 {
lab=shreg[2]}
N 3580 920 3560 920 {
lab=rx_data[3]}
N 3620 940 3620 960 {
lab=_070_}
N 3640 860 3660 860 {
lab=VDD}
N 3670 900 3690 900 {
lab=_021_}
N 3640 940 3660 940 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3950 900 0 0 {name=_381_}
N 3930 880 3910 880 {
lab=shreg[1]}
N 3930 920 3910 920 {
lab=rx_data[2]}
N 3970 940 3970 960 {
lab=_070_}
N 3990 860 4010 860 {
lab=VDD}
N 4020 900 4040 900 {
lab=_022_}
N 3990 940 4010 940 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 4300 900 0 0 {name=_382_}
N 4280 880 4260 880 {
lab=shreg[0]}
N 4280 920 4260 920 {
lab=rx_data[1]}
N 4320 940 4320 960 {
lab=_070_}
N 4340 860 4360 860 {
lab=VDD}
N 4370 900 4390 900 {
lab=_023_}
N 4340 940 4360 940 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 4650 900 0 0 {name=_383_}
N 4630 880 4610 880 {
lab=sda_in}
N 4630 920 4610 920 {
lab=rx_data[0]}
N 4670 940 4670 960 {
lab=_070_}
N 4690 860 4710 860 {
lab=VDD}
N 4720 900 4740 900 {
lab=_024_}
N 4690 940 4710 940 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 800 1200 0 0 {name=_384_}
N 830 1140 830 1120 {
lab=VDD}
N 910 1200 930 1200 {
lab=_071_}
N 780 1180 760 1180 {
lab=bit_cnt[3]}
N 780 1220 760 1220 {
lab=bit_cnt[2]}
N 830 1260 830 1280 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1150 1200 0 0 {name=_385_}
N 1180 1140 1180 1120 {
lab=VDD}
N 1280 1200 1300 1200 {
lab=_072_}
N 1130 1180 1110 1180 {
lab=_066_}
N 1130 1220 1110 1220 {
lab=_071_}
N 1180 1260 1180 1280 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1500 1200 0 0 {name=_386_}
N 1530 1140 1530 1120 {
lab=VDD}
N 1610 1200 1630 1200 {
lab=_073_}
N 1480 1180 1460 1180 {
lab=_047_}
N 1480 1220 1460 1220 {
lab=_072_}
N 1530 1260 1530 1280 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 1850 1200 0 0 {name=_387_}
N 1830 1180 1810 1180 {
lab=tx_data[6]}
N 1830 1220 1810 1220 {
lab=txreg[6]}
N 1870 1240 1870 1260 {
lab=_073_}
N 1890 1160 1910 1160 {
lab=VDD}
N 1920 1200 1940 1200 {
lab=_025_}
N 1890 1240 1910 1240 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2200 1200 0 0 {name=_388_}
N 2180 1180 2160 1180 {
lab=tx_data[5]}
N 2180 1220 2160 1220 {
lab=txreg[5]}
N 2220 1240 2220 1260 {
lab=_073_}
N 2240 1160 2260 1160 {
lab=VDD}
N 2270 1200 2290 1200 {
lab=_026_}
N 2240 1240 2260 1240 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2550 1200 0 0 {name=_389_}
N 2530 1180 2510 1180 {
lab=tx_data[4]}
N 2530 1220 2510 1220 {
lab=txreg[4]}
N 2570 1240 2570 1260 {
lab=_073_}
N 2590 1160 2610 1160 {
lab=VDD}
N 2620 1200 2640 1200 {
lab=_027_}
N 2590 1240 2610 1240 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2900 1200 0 0 {name=_390_}
N 2880 1180 2860 1180 {
lab=tx_data[3]}
N 2880 1220 2860 1220 {
lab=txreg[3]}
N 2920 1240 2920 1260 {
lab=_073_}
N 2940 1160 2960 1160 {
lab=VDD}
N 2970 1200 2990 1200 {
lab=_028_}
N 2940 1240 2960 1240 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3250 1200 0 0 {name=_391_}
N 3230 1180 3210 1180 {
lab=tx_data[2]}
N 3230 1220 3210 1220 {
lab=txreg[2]}
N 3270 1240 3270 1260 {
lab=_073_}
N 3290 1160 3310 1160 {
lab=VDD}
N 3320 1200 3340 1200 {
lab=_029_}
N 3290 1240 3310 1240 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3600 1200 0 0 {name=_392_}
N 3580 1180 3560 1180 {
lab=tx_data[1]}
N 3580 1220 3560 1220 {
lab=txreg[1]}
N 3620 1240 3620 1260 {
lab=_073_}
N 3640 1160 3660 1160 {
lab=VDD}
N 3670 1200 3690 1200 {
lab=_030_}
N 3640 1240 3660 1240 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3950 1200 0 0 {name=_393_}
N 3930 1180 3910 1180 {
lab=tx_data[0]}
N 3930 1220 3910 1220 {
lab=txreg[0]}
N 3970 1240 3970 1260 {
lab=_073_}
N 3990 1160 4010 1160 {
lab=VDD}
N 4020 1200 4040 1200 {
lab=_031_}
N 3990 1240 4010 1240 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4300 1200 0 0 {name=_394_}
N 4330 1140 4330 1120 {
lab=VDD}
N 4410 1200 4430 1200 {
lab=_074_}
N 4280 1180 4260 1180 {
lab=phase[1]}
N 4280 1220 4260 1220 {
lab=_058_}
N 4330 1260 4330 1280 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4650 1200 0 0 {name=_395_}
N 4680 1140 4680 1120 {
lab=VDD}
N 4780 1200 4800 1200 {
lab=_075_}
N 4630 1180 4610 1180 {
lab=addr_match}
N 4630 1220 4610 1220 {
lab=_114_}
N 4680 1260 4680 1280 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 800 1500 0 0 {name=_396_}
N 830 1440 830 1420 {
lab=VDD}
N 910 1500 930 1500 {
lab=_076_}
N 780 1480 760 1480 {
lab=_052_}
N 780 1520 760 1520 {
lab=_075_}
N 830 1560 830 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1150 1500 0 0 {name=_397_}
N 1180 1440 1180 1420 {
lab=VDD}
N 1280 1500 1300 1500 {
lab=_077_}
N 1130 1480 1110 1480 {
lab=sda_in}
N 1130 1520 1110 1520 {
lab=_051_}
N 1180 1560 1180 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1500 1500 0 0 {name=_398_}
N 1530 1440 1530 1420 {
lab=VDD}
N 1630 1500 1650 1500 {
lab=_078_}
N 1480 1480 1460 1480 {
lab=_070_}
N 1480 1520 1460 1520 {
lab=_077_}
N 1530 1560 1530 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1850 1500 0 0 {name=_399_}
N 1880 1440 1880 1420 {
lab=VDD}
N 1980 1500 2000 1500 {
lab=_079_}
N 1830 1480 1810 1480 {
lab=_054_}
N 1830 1520 1810 1520 {
lab=_058_}
N 1880 1560 1880 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 2200 1500 0 0 {name=_400_}
N 2190 1470 2190 1450 {
lab=rx_valid}
N 2190 1490 2170 1490 {
lab=_076_}
N 2190 1510 2170 1510 {
lab=_078_}
N 2190 1530 2190 1550 {
lab=_079_}
N 2230 1440 2230 1420 {
lab=VDD}
N 2310 1500 2330 1500 {
lab=_080_}
N 2230 1560 2230 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2550 1500 0 0 {name=_401_}
N 2580 1440 2580 1420 {
lab=VDD}
N 2660 1500 2680 1500 {
lab=_032_}
N 2530 1480 2510 1480 {
lab=_074_}
N 2530 1520 2510 1520 {
lab=_080_}
N 2580 1560 2580 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 2900 1500 0 0 {name=_402_}
N 2930 1440 2930 1420 {
lab=VDD}
N 3010 1500 3030 1500 {
lab=_033_}
N 2880 1480 2860 1480 {
lab=_049_}
N 2880 1520 2860 1520 {
lab=_057_}
N 2930 1560 2930 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3250 1500 0 0 {name=_403_}
N 3280 1440 3280 1420 {
lab=VDD}
N 3360 1500 3380 1500 {
lab=_081_}
N 3230 1480 3210 1480 {
lab=phase[2]}
N 3230 1520 3210 1520 {
lab=_058_}
N 3280 1560 3280 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3600 1500 0 0 {name=_404_}
N 3630 1440 3630 1420 {
lab=VDD}
N 3730 1500 3750 1500 {
lab=_082_}
N 3580 1480 3560 1480 {
lab=addr_match}
N 3580 1520 3560 1520 {
lab=_115_}
N 3630 1560 3630 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3950 1500 0 0 {name=_405_}
N 3980 1440 3980 1420 {
lab=VDD}
N 4060 1500 4080 1500 {
lab=_083_}
N 3930 1480 3910 1480 {
lab=_052_}
N 3930 1520 3910 1520 {
lab=_082_}
N 3980 1560 3980 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 4300 1500 0 0 {name=_406_}
N 4290 1470 4290 1450 {
lab=_046_}
N 4290 1490 4270 1490 {
lab=_051_}
N 4290 1510 4270 1510 {
lab=_079_}
N 4290 1530 4290 1550 {
lab=_083_}
N 4330 1440 4330 1420 {
lab=VDD}
N 4410 1500 4430 1500 {
lab=_084_}
N 4330 1560 4330 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4650 1500 0 0 {name=_407_}
N 4680 1440 4680 1420 {
lab=VDD}
N 4760 1500 4780 1500 {
lab=_034_}
N 4630 1480 4610 1480 {
lab=_081_}
N 4630 1520 4610 1520 {
lab=_084_}
N 4680 1560 4680 1580 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 800 1800 0 0 {name=_408_}
N 830 1740 830 1720 {
lab=VDD}
N 930 1800 950 1800 {
lab=_085_}
N 780 1780 760 1780 {
lab=_121_}
N 780 1820 760 1820 {
lab=_057_}
N 830 1860 830 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 1150 1800 0 0 {name=_409_}
N 1130 1780 1110 1780 {
lab=sda_in}
N 1130 1820 1110 1820 {
lab=rw}
N 1170 1840 1170 1860 {
lab=_085_}
N 1190 1760 1210 1760 {
lab=VDD}
N 1220 1800 1240 1800 {
lab=_035_}
N 1190 1840 1210 1840 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1500 1800 0 0 {name=_410_}
N 1530 1740 1530 1720 {
lab=VDD}
N 1610 1800 1630 1800 {
lab=_086_}
N 1480 1780 1460 1780 {
lab=tx_data[7]}
N 1480 1820 1460 1820 {
lab=_073_}
N 1530 1860 1530 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 1850 1800 0 0 {name=_411_}
N 1830 1780 1810 1780 {
lab=tx_data[7]}
N 1830 1820 1810 1820 {
lab=txreg[7]}
N 1870 1840 1870 1860 {
lab=_073_}
N 1890 1760 1910 1760 {
lab=VDD}
N 1920 1800 1940 1800 {
lab=_036_}
N 1890 1840 1910 1840 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2200 1800 0 0 {name=_412_}
N 2180 1780 2160 1780 {
lab=shreg[6]}
N 2180 1820 2160 1820 {
lab=rx_data[7]}
N 2220 1840 2220 1860 {
lab=_070_}
N 2240 1760 2260 1760 {
lab=VDD}
N 2270 1800 2290 1800 {
lab=_037_}
N 2240 1840 2260 1840 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2550 1800 0 0 {name=_413_}
N 2530 1820 2510 1820 {
lab=txreg[6]}
N 2580 1740 2580 1720 {
lab=VDD}
N 2680 1800 2700 1800 {
lab=_087_}
N 2530 1780 2510 1780 {
lab=bit_cnt[0]}
N 2530 1800 2510 1800 {
lab=_111_}
N 2580 1860 2580 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2900 1800 0 0 {name=_414_}
N 2930 1740 2930 1720 {
lab=VDD}
N 3030 1800 3050 1800 {
lab=_088_}
N 2880 1780 2860 1780 {
lab=txreg[7]}
N 2880 1820 2860 1820 {
lab=_066_}
N 2930 1860 2930 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3250 1800 0 0 {name=_415_}
N 3280 1740 3280 1720 {
lab=VDD}
N 3380 1800 3400 1800 {
lab=_089_}
N 3230 1780 3210 1780 {
lab=txreg[4]}
N 3230 1820 3210 1820 {
lab=_055_}
N 3280 1860 3280 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 3600 1800 0 0 {name=_416_}
N 3580 1820 3560 1820 {
lab=txreg[5]}
N 3630 1740 3630 1720 {
lab=VDD}
N 3730 1800 3750 1800 {
lab=_090_}
N 3580 1780 3560 1780 {
lab=_110_}
N 3580 1800 3560 1800 {
lab=bit_cnt[1]}
N 3630 1860 3630 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND4.sym} 3950 1800 0 0 {name=_417_}
N 3930 1770 3930 1750 {
lab=_087_}
N 3930 1790 3910 1790 {
lab=_088_}
N 3930 1810 3910 1810 {
lab=_090_}
N 3930 1830 3930 1850 {
lab=_089_}
N 3980 1740 3980 1720 {
lab=VDD}
N 4080 1800 4100 1800 {
lab=_091_}
N 3980 1860 3980 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4300 1800 0 0 {name=_418_}
N 4330 1740 4330 1720 {
lab=VDD}
N 4430 1800 4450 1800 {
lab=_092_}
N 4280 1780 4260 1780 {
lab=_011_}
N 4280 1820 4260 1820 {
lab=_091_}
N 4330 1860 4330 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4650 1800 0 0 {name=_419_}
N 4680 1740 4680 1720 {
lab=VDD}
N 4780 1800 4800 1800 {
lab=_093_}
N 4630 1780 4610 1780 {
lab=_112_}
N 4630 1820 4610 1820 {
lab=_092_}
N 4680 1860 4680 1880 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 800 2100 0 0 {name=_420_}
N 830 2040 830 2020 {
lab=VDD}
N 930 2100 950 2100 {
lab=_094_}
N 780 2080 760 2080 {
lab=txreg[3]}
N 780 2120 760 2120 {
lab=_066_}
N 830 2160 830 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 1150 2100 0 0 {name=_421_}
N 1130 2120 1110 2120 {
lab=txreg[2]}
N 1180 2040 1180 2020 {
lab=VDD}
N 1280 2100 1300 2100 {
lab=_095_}
N 1130 2080 1110 2080 {
lab=bit_cnt[0]}
N 1130 2100 1110 2100 {
lab=_111_}
N 1180 2160 1180 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 1500 2100 0 0 {name=_422_}
N 1480 2120 1460 2120 {
lab=txreg[1]}
N 1530 2040 1530 2020 {
lab=VDD}
N 1630 2100 1650 2100 {
lab=_096_}
N 1480 2080 1460 2080 {
lab=_110_}
N 1480 2100 1460 2100 {
lab=bit_cnt[1]}
N 1530 2160 1530 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1850 2100 0 0 {name=_423_}
N 1880 2040 1880 2020 {
lab=VDD}
N 1980 2100 2000 2100 {
lab=_097_}
N 1830 2080 1810 2080 {
lab=txreg[0]}
N 1830 2120 1810 2120 {
lab=_055_}
N 1880 2160 1880 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND4.sym} 2200 2100 0 0 {name=_424_}
N 2180 2070 2180 2050 {
lab=_094_}
N 2180 2090 2160 2090 {
lab=_095_}
N 2180 2110 2160 2110 {
lab=_097_}
N 2180 2130 2180 2150 {
lab=_096_}
N 2230 2040 2230 2020 {
lab=VDD}
N 2330 2100 2350 2100 {
lab=_098_}
N 2230 2160 2230 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2550 2100 0 0 {name=_425_}
N 2580 2040 2580 2020 {
lab=VDD}
N 2660 2100 2680 2100 {
lab=_099_}
N 2530 2080 2510 2080 {
lab=_112_}
N 2530 2120 2510 2120 {
lab=_098_}
N 2580 2160 2580 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 2900 2100 0 0 {name=_426_}
N 2880 2100 2860 2100 {
lab=_113_}
N 2880 2120 2860 2120 {
lab=_099_}
N 2930 2040 2930 2020 {
lab=VDD}
N 3010 2100 3030 2100 {
lab=_100_}
N 2880 2080 2860 2080 {
lab=bit_cnt[3]}
N 2930 2160 2930 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3250 2100 0 0 {name=_427_}
N 3280 2040 3280 2020 {
lab=VDD}
N 3380 2100 3400 2100 {
lab=_101_}
N 3230 2080 3210 2080 {
lab=_093_}
N 3230 2120 3210 2120 {
lab=_100_}
N 3280 2160 3280 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 3600 2100 0 0 {name=_428_}
N 3580 2120 3560 2120 {
lab=_101_}
N 3630 2040 3630 2020 {
lab=VDD}
N 3730 2100 3750 2100 {
lab=_102_}
N 3580 2080 3560 2080 {
lab=_046_}
N 3580 2100 3560 2100 {
lab=_072_}
N 3630 2160 3630 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3950 2100 0 0 {name=_429_}
N 3980 2040 3980 2020 {
lab=VDD}
N 4060 2100 4080 2100 {
lab=_103_}
N 3930 2080 3910 2080 {
lab=addr_match}
N 3930 2120 3910 2120 {
lab=_052_}
N 3980 2160 3980 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 4300 2100 0 0 {name=_430_}
N 4280 2100 4260 2100 {
lab=_086_}
N 4280 2120 4260 2120 {
lab=_103_}
N 4330 2040 4330 2020 {
lab=VDD}
N 4410 2100 4430 2100 {
lab=_104_}
N 4280 2080 4260 2080 {
lab=rx_valid}
N 4330 2160 4330 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4650 2100 0 0 {name=_431_}
N 4680 2040 4680 2020 {
lab=VDD}
N 4780 2100 4800 2100 {
lab=_002_}
N 4630 2080 4610 2080 {
lab=_102_}
N 4630 2120 4610 2120 {
lab=_104_}
N 4680 2160 4680 2180 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 800 2400 0 0 {name=_432_}
N 830 2340 830 2320 {
lab=VDD}
N 930 2400 950 2400 {
lab=rst_sdaoe_domain}
N 780 2380 760 2380 {
lab=busy}
N 780 2420 760 2420 {
lab=rst_n}
N 830 2460 830 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 1150 2400 0 0 {name=_433_}
N 1180 2340 1180 2320 {
lab=VDD}
N 1280 2400 1300 2400 {
lab=_105_}
N 1130 2380 1110 2380 {
lab=scl}
N 1130 2420 1110 2420 {
lab=sda_d}
N 1180 2460 1180 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1500 2400 0 0 {name=_434_}
N 1530 2340 1530 2320 {
lab=VDD}
N 1610 2400 1630 2400 {
lab=start_pulse}
N 1480 2380 1460 2380 {
lab=sda_in}
N 1480 2420 1460 2420 {
lab=_105_}
N 1530 2460 1530 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1850 2400 0 0 {name=_435_}
N 1880 2340 1880 2320 {
lab=VDD}
N 1960 2400 1980 2400 {
lab=rst_scl_domain}
N 1830 2380 1810 2380 {
lab=_116_}
N 1830 2420 1810 2420 {
lab=start_pulse}
N 1880 2460 1880 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2200 2400 0 0 {name=_436_}
N 2230 2340 2230 2320 {
lab=VDD}
N 2310 2400 2330 2400 {
lab=_106_}
N 2180 2380 2160 2380 {
lab=_056_}
N 2180 2420 2160 2420 {
lab=_059_}
N 2230 2460 2230 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 2550 2400 0 0 {name=_437_}
N 2530 2380 2510 2380 {
lab=_106_}
N 2530 2420 2510 2420 {
lab=_062_}
N 2570 2440 2570 2460 {
lab=bit_cnt[3]}
N 2590 2360 2610 2360 {
lab=VDD}
N 2620 2400 2640 2400 {
lab=_038_}
N 2590 2440 2610 2440 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2900 2400 0 0 {name=_438_}
N 2880 2420 2860 2420 {
lab=_117_}
N 2930 2340 2930 2320 {
lab=VDD}
N 3030 2400 3050 2400 {
lab=_107_}
N 2880 2380 2860 2380 {
lab=sda_in}
N 2880 2400 2860 2400 {
lab=scl}
N 2930 2460 2930 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3250 2400 0 0 {name=_439_}
N 3280 2340 3280 2320 {
lab=VDD}
N 3380 2400 3400 2400 {
lab=busy_clr}
N 3230 2380 3210 2380 {
lab=rst_n}
N 3230 2420 3210 2420 {
lab=_107_}
N 3280 2460 3280 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR4.sym} 3600 2400 0 0 {name=_440_}
N 3590 2370 3590 2350 {
lab=_013_}
N 3590 2390 3570 2390 {
lab=_012_}
N 3590 2410 3570 2410 {
lab=shreg[5]}
N 3590 2430 3590 2450 {
lab=shreg[2]}
N 3630 2340 3630 2320 {
lab=VDD}
N 3710 2400 3730 2400 {
lab=_108_}
N 3630 2460 3630 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 3950 2400 0 0 {name=_441_}
N 3940 2370 3940 2350 {
lab=shreg[3]}
N 3940 2390 3920 2390 {
lab=shreg[0]}
N 3940 2410 3920 2410 {
lab=shreg[1]}
N 3940 2430 3940 2450 {
lab=_108_}
N 3980 2340 3980 2320 {
lab=VDD}
N 4060 2400 4080 2400 {
lab=_109_}
N 3980 2460 3980 2480 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 4300 2400 0 0 {name=_442_}
N 4280 2380 4260 2380 {
lab=_109_}
N 4280 2420 4260 2420 {
lab=addr_match}
N 4320 2440 4320 2460 {
lab=_085_}
N 4340 2360 4360 2360 {
lab=VDD}
N 4370 2400 4390 2400 {
lab=_039_}
N 4340 2440 4360 2440 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4650 2400 0 0 {name=_443_}
N 4620 2340 4620 2320 {
lab=VDD}
N 4680 2410 4700 2410 {
lab=_014_}
N 4620 2370 4600 2370 {
lab=_033_}
N 4680 2370 4700 2370 {
lab=phase[0]}
N 4650 2440 4650 2460 {
lab=rst_scl_domain}
N 4620 2460 4620 2480 {
lab=GND}
N 4620 2410 4600 2410 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 800 2700 0 0 {name=_444_}
N 770 2640 770 2620 {
lab=VDD}
N 830 2710 850 2710 {
lab=_008_}
N 770 2670 750 2670 {
lab=_032_}
N 830 2670 850 2670 {
lab=phase[1]}
N 800 2740 800 2760 {
lab=rst_scl_domain}
N 770 2760 770 2780 {
lab=GND}
N 770 2710 750 2710 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1150 2700 0 0 {name=_445_}
N 1120 2640 1120 2620 {
lab=VDD}
N 1180 2710 1200 2710 {
lab=_007_}
N 1120 2670 1100 2670 {
lab=_034_}
N 1180 2670 1200 2670 {
lab=phase[2]}
N 1150 2740 1150 2760 {
lab=rst_scl_domain}
N 1120 2760 1120 2780 {
lab=GND}
N 1120 2710 1100 2710 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1500 2700 0 0 {name=_446_}
N 1470 2640 1470 2620 {
lab=VDD}
N 1530 2710 1550 2710 {
lab=_006_}
N 1470 2670 1450 2670 {
lab=_035_}
N 1530 2670 1550 2670 {
lab=rw}
N 1500 2740 1500 2760 {
lab=rst_scl_domain}
N 1470 2760 1470 2780 {
lab=GND}
N 1470 2710 1450 2710 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1850 2700 0 0 {name=_447_}
N 1820 2640 1820 2620 {
lab=VDD}
N 1880 2710 1900 2710 {
lab=_176_}
N 1820 2670 1800 2670 {
lab=_031_}
N 1880 2670 1900 2670 {
lab=txreg[0]}
N 1850 2740 1850 2760 {
lab=rst_sdaoe_domain}
N 1820 2760 1820 2780 {
lab=GND}
N 1820 2710 1800 2710 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2200 2700 0 0 {name=_448_}
N 2170 2640 2170 2620 {
lab=VDD}
N 2230 2710 2250 2710 {
lab=_177_}
N 2170 2670 2150 2670 {
lab=_030_}
N 2230 2670 2250 2670 {
lab=txreg[1]}
N 2200 2740 2200 2760 {
lab=rst_sdaoe_domain}
N 2170 2760 2170 2780 {
lab=GND}
N 2170 2710 2150 2710 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2550 2700 0 0 {name=_449_}
N 2520 2640 2520 2620 {
lab=VDD}
N 2580 2710 2600 2710 {
lab=_178_}
N 2520 2670 2500 2670 {
lab=_029_}
N 2580 2670 2600 2670 {
lab=txreg[2]}
N 2550 2740 2550 2760 {
lab=rst_sdaoe_domain}
N 2520 2760 2520 2780 {
lab=GND}
N 2520 2710 2500 2710 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2900 2700 0 0 {name=_450_}
N 2870 2640 2870 2620 {
lab=VDD}
N 2930 2710 2950 2710 {
lab=_179_}
N 2870 2670 2850 2670 {
lab=_028_}
N 2930 2670 2950 2670 {
lab=txreg[3]}
N 2900 2740 2900 2760 {
lab=rst_sdaoe_domain}
N 2870 2760 2870 2780 {
lab=GND}
N 2870 2710 2850 2710 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3250 2700 0 0 {name=_451_}
N 3220 2640 3220 2620 {
lab=VDD}
N 3280 2710 3300 2710 {
lab=_180_}
N 3220 2670 3200 2670 {
lab=_027_}
N 3280 2670 3300 2670 {
lab=txreg[4]}
N 3250 2740 3250 2760 {
lab=rst_sdaoe_domain}
N 3220 2760 3220 2780 {
lab=GND}
N 3220 2710 3200 2710 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3600 2700 0 0 {name=_452_}
N 3570 2640 3570 2620 {
lab=VDD}
N 3630 2710 3650 2710 {
lab=_181_}
N 3570 2670 3550 2670 {
lab=_026_}
N 3630 2670 3650 2670 {
lab=txreg[5]}
N 3600 2740 3600 2760 {
lab=rst_sdaoe_domain}
N 3570 2760 3570 2780 {
lab=GND}
N 3570 2710 3550 2710 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3950 2700 0 0 {name=_453_}
N 3920 2640 3920 2620 {
lab=VDD}
N 3980 2710 4000 2710 {
lab=_182_}
N 3920 2670 3900 2670 {
lab=_025_}
N 3980 2670 4000 2670 {
lab=txreg[6]}
N 3950 2740 3950 2760 {
lab=rst_sdaoe_domain}
N 3920 2760 3920 2780 {
lab=GND}
N 3920 2710 3900 2710 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4300 2700 0 0 {name=_454_}
N 4270 2640 4270 2620 {
lab=VDD}
N 4330 2710 4350 2710 {
lab=_198_}
N 4270 2670 4250 2670 {
lab=_036_}
N 4330 2670 4350 2670 {
lab=txreg[7]}
N 4300 2740 4300 2760 {
lab=rst_sdaoe_domain}
N 4270 2760 4270 2780 {
lab=GND}
N 4270 2710 4250 2710 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4650 2700 0 0 {name=_455_}
N 4620 2640 4620 2620 {
lab=VDD}
N 4680 2710 4700 2710 {
lab=_183_}
N 4620 2670 4600 2670 {
lab=_024_}
N 4680 2670 4700 2670 {
lab=rx_data[0]}
N 4650 2740 4650 2760 {
lab=rst_scl_domain}
N 4620 2760 4620 2780 {
lab=GND}
N 4620 2710 4600 2710 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 800 3000 0 0 {name=_456_}
N 770 2940 770 2920 {
lab=VDD}
N 830 3010 850 3010 {
lab=_184_}
N 770 2970 750 2970 {
lab=_023_}
N 830 2970 850 2970 {
lab=rx_data[1]}
N 800 3040 800 3060 {
lab=rst_scl_domain}
N 770 3060 770 3080 {
lab=GND}
N 770 3010 750 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1150 3000 0 0 {name=_457_}
N 1120 2940 1120 2920 {
lab=VDD}
N 1180 3010 1200 3010 {
lab=_185_}
N 1120 2970 1100 2970 {
lab=_022_}
N 1180 2970 1200 2970 {
lab=rx_data[2]}
N 1150 3040 1150 3060 {
lab=rst_scl_domain}
N 1120 3060 1120 3080 {
lab=GND}
N 1120 3010 1100 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1500 3000 0 0 {name=_458_}
N 1470 2940 1470 2920 {
lab=VDD}
N 1530 3010 1550 3010 {
lab=_186_}
N 1470 2970 1450 2970 {
lab=_021_}
N 1530 2970 1550 2970 {
lab=rx_data[3]}
N 1500 3040 1500 3060 {
lab=rst_scl_domain}
N 1470 3060 1470 3080 {
lab=GND}
N 1470 3010 1450 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1850 3000 0 0 {name=_459_}
N 1820 2940 1820 2920 {
lab=VDD}
N 1880 3010 1900 3010 {
lab=_187_}
N 1820 2970 1800 2970 {
lab=_020_}
N 1880 2970 1900 2970 {
lab=rx_data[4]}
N 1850 3040 1850 3060 {
lab=rst_scl_domain}
N 1820 3060 1820 3080 {
lab=GND}
N 1820 3010 1800 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2200 3000 0 0 {name=_460_}
N 2170 2940 2170 2920 {
lab=VDD}
N 2230 3010 2250 3010 {
lab=_188_}
N 2170 2970 2150 2970 {
lab=_019_}
N 2230 2970 2250 2970 {
lab=rx_data[5]}
N 2200 3040 2200 3060 {
lab=rst_scl_domain}
N 2170 3060 2170 3080 {
lab=GND}
N 2170 3010 2150 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2550 3000 0 0 {name=_461_}
N 2520 2940 2520 2920 {
lab=VDD}
N 2580 3010 2600 3010 {
lab=_189_}
N 2520 2970 2500 2970 {
lab=_018_}
N 2580 2970 2600 2970 {
lab=rx_data[6]}
N 2550 3040 2550 3060 {
lab=rst_scl_domain}
N 2520 3060 2520 3080 {
lab=GND}
N 2520 3010 2500 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2900 3000 0 0 {name=_462_}
N 2870 2940 2870 2920 {
lab=VDD}
N 2930 3010 2950 3010 {
lab=_199_}
N 2870 2970 2850 2970 {
lab=_037_}
N 2930 2970 2950 2970 {
lab=rx_data[7]}
N 2900 3040 2900 3060 {
lab=rst_scl_domain}
N 2870 3060 2870 3080 {
lab=GND}
N 2870 3010 2850 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3250 3000 0 0 {name=_463_}
N 3220 2940 3220 2920 {
lab=VDD}
N 3280 3010 3300 3010 {
lab=_009_}
N 3220 2970 3200 2970 {
lab=_017_}
N 3280 2970 3300 2970 {
lab=bit_cnt[0]}
N 3250 3040 3250 3060 {
lab=rst_scl_domain}
N 3220 3060 3220 3080 {
lab=GND}
N 3220 3010 3200 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3600 3000 0 0 {name=_464_}
N 3570 2940 3570 2920 {
lab=VDD}
N 3630 3010 3650 3010 {
lab=_010_}
N 3570 2970 3550 2970 {
lab=_016_}
N 3630 2970 3650 2970 {
lab=bit_cnt[1]}
N 3600 3040 3600 3060 {
lab=rst_scl_domain}
N 3570 3060 3570 3080 {
lab=GND}
N 3570 3010 3550 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3950 3000 0 0 {name=_465_}
N 3920 2940 3920 2920 {
lab=VDD}
N 3980 3010 4000 3010 {
lab=_011_}
N 3920 2970 3900 2970 {
lab=_015_}
N 3980 2970 4000 2970 {
lab=bit_cnt[2]}
N 3950 3040 3950 3060 {
lab=rst_scl_domain}
N 3920 3060 3920 3080 {
lab=GND}
N 3920 3010 3900 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4300 3000 0 0 {name=_466_}
N 4270 2940 4270 2920 {
lab=VDD}
N 4330 3010 4350 3010 {
lab=_005_}
N 4270 2970 4250 2970 {
lab=_038_}
N 4330 2970 4350 2970 {
lab=bit_cnt[3]}
N 4300 3040 4300 3060 {
lab=rst_scl_domain}
N 4270 3060 4270 3080 {
lab=GND}
N 4270 3010 4250 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4650 3000 0 0 {name=_467_}
N 4620 2940 4620 2920 {
lab=VDD}
N 4680 3010 4700 3010 {
lab=_168_}
N 4620 2970 4600 2970 {
lab=_039_}
N 4680 2970 4700 2970 {
lab=addr_match}
N 4650 3040 4650 3060 {
lab=rst_scl_domain}
N 4620 3060 4620 3080 {
lab=GND}
N 4620 3010 4600 3010 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 800 3300 0 0 {name=_468_}
N 770 3240 770 3220 {
lab=VDD}
N 830 3310 850 3310 {
lab=_171_}
N 770 3270 750 3270 {
lab=_002_}
N 830 3270 850 3270 {
lab=sda_oe}
N 800 3340 800 3360 {
lab=rst_sdaoe_domain}
N 770 3360 770 3380 {
lab=GND}
N 770 3310 750 3310 {
lab=scl_n}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1150 3300 0 0 {name=_469_}
N 1120 3240 1120 3220 {
lab=VDD}
N 1180 3310 1200 3310 {
lab=_170_}
N 1120 3270 1100 3270 {
lab=sda_in}
N 1180 3270 1200 3270 {
lab=shreg[0]}
N 1150 3340 1150 3360 {
lab=rst_scl_domain}
N 1120 3360 1120 3380 {
lab=GND}
N 1120 3310 1100 3310 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1500 3300 0 0 {name=_470_}
N 1470 3240 1470 3220 {
lab=VDD}
N 1530 3310 1550 3310 {
lab=_167_}
N 1470 3270 1450 3270 {
lab=shreg[0]}
N 1530 3270 1550 3270 {
lab=shreg[1]}
N 1500 3340 1500 3360 {
lab=rst_scl_domain}
N 1470 3360 1470 3380 {
lab=GND}
N 1470 3310 1450 3310 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 1850 3300 0 0 {name=_471_}
N 1820 3240 1820 3220 {
lab=VDD}
N 1880 3310 1900 3310 {
lab=_174_}
N 1820 3270 1800 3270 {
lab=shreg[1]}
N 1880 3270 1900 3270 {
lab=shreg[2]}
N 1850 3340 1850 3360 {
lab=rst_scl_domain}
N 1820 3360 1820 3380 {
lab=GND}
N 1820 3310 1800 3310 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2200 3300 0 0 {name=_472_}
N 2170 3240 2170 3220 {
lab=VDD}
N 2230 3310 2250 3310 {
lab=_197_}
N 2170 3270 2150 3270 {
lab=shreg[2]}
N 2230 3270 2250 3270 {
lab=shreg[3]}
N 2200 3340 2200 3360 {
lab=rst_scl_domain}
N 2170 3360 2170 3380 {
lab=GND}
N 2170 3310 2150 3310 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2550 3300 0 0 {name=_473_}
N 2520 3240 2520 3220 {
lab=VDD}
N 2580 3310 2600 3310 {
lab=_012_}
N 2520 3270 2500 3270 {
lab=shreg[3]}
N 2580 3270 2600 3270 {
lab=shreg[4]}
N 2550 3340 2550 3360 {
lab=rst_scl_domain}
N 2520 3360 2520 3380 {
lab=GND}
N 2520 3310 2500 3310 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 2900 3300 0 0 {name=_474_}
N 2870 3240 2870 3220 {
lab=VDD}
N 2930 3310 2950 3310 {
lab=_194_}
N 2870 3270 2850 3270 {
lab=shreg[4]}
N 2930 3270 2950 3270 {
lab=shreg[5]}
N 2900 3340 2900 3360 {
lab=rst_scl_domain}
N 2870 3360 2870 3380 {
lab=GND}
N 2870 3310 2850 3310 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3250 3300 0 0 {name=_475_}
N 3220 3240 3220 3220 {
lab=VDD}
N 3280 3310 3300 3310 {
lab=_013_}
N 3220 3270 3200 3270 {
lab=shreg[5]}
N 3280 3270 3300 3270 {
lab=shreg[6]}
N 3250 3340 3250 3360 {
lab=rst_scl_domain}
N 3220 3360 3220 3380 {
lab=GND}
N 3220 3310 3200 3310 {
lab=scl}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DEL1.sym} 3600 3300 0 0 {name=u_del_sda}
N 3630 3260 3630 3240 {
lab=VDD}
N 3580 3300 3560 3300 {
lab=sda_in}
N 3700 3300 3720 3300 {
lab=sda_d}
N 3630 3340 3630 3360 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3950 3300 0 0 {name=u_inv_scl}
N 3980 3260 3980 3240 {
lab=VDD}
N 3930 3300 3910 3300 {
lab=scl}
N 4050 3300 4070 3300 {
lab=scl_n}
N 3980 3340 3980 3360 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4300 3300 0 0 {name=u_lat_q}
N 4330 3240 4330 3220 {
lab=VDD}
N 4410 3300 4430 3300 {
lab=busy}
N 4280 3280 4260 3280 {
lab=busy_clr}
N 4280 3320 4260 3320 {
lab=qn}
N 4330 3360 4330 3380 {
lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4650 3300 0 0 {name=u_lat_qn}
N 4680 3240 4680 3220 {
lab=VDD}
N 4760 3300 4780 3300 {
lab=qn}
N 4630 3280 4610 3280 {
lab=start_pulse}
N 4630 3320 4610 3320 {
lab=busy}
N 4680 3360 4680 3380 {
lab=GND}
C {devices/iopin.sym} 0 -200 0 0 {name=io_VDD lab=VDD}
C {devices/iopin.sym} 0 -140 0 0 {name=io_GND lab=GND}
C {devices/ipin.sym} 0 -80 0 0 {name=io_rst_n lab=rst_n}
C {devices/ipin.sym} 0 -20 0 0 {name=io_scl lab=scl}
C {devices/ipin.sym} 0 40 0 0 {name=io_sda_in lab=sda_in}
C {devices/ipin.sym} 0 100 0 0 {name=io_tx_data_7_ lab=tx_data[7]}
C {devices/ipin.sym} 0 160 0 0 {name=io_tx_data_6_ lab=tx_data[6]}
C {devices/ipin.sym} 0 220 0 0 {name=io_tx_data_5_ lab=tx_data[5]}
C {devices/ipin.sym} 0 280 0 0 {name=io_tx_data_4_ lab=tx_data[4]}
C {devices/ipin.sym} 0 340 0 0 {name=io_tx_data_3_ lab=tx_data[3]}
C {devices/ipin.sym} 0 400 0 0 {name=io_tx_data_2_ lab=tx_data[2]}
C {devices/ipin.sym} 0 460 0 0 {name=io_tx_data_1_ lab=tx_data[1]}
C {devices/ipin.sym} 0 520 0 0 {name=io_tx_data_0_ lab=tx_data[0]}
C {devices/opin.sym} 5200 -200 0 0 {name=io_sda_oe lab=sda_oe}
C {devices/opin.sym} 5200 -140 0 0 {name=io_rx_data_7_ lab=rx_data[7]}
C {devices/opin.sym} 5200 -80 0 0 {name=io_rx_data_6_ lab=rx_data[6]}
C {devices/opin.sym} 5200 -20 0 0 {name=io_rx_data_5_ lab=rx_data[5]}
C {devices/opin.sym} 5200 40 0 0 {name=io_rx_data_4_ lab=rx_data[4]}
C {devices/opin.sym} 5200 100 0 0 {name=io_rx_data_3_ lab=rx_data[3]}
C {devices/opin.sym} 5200 160 0 0 {name=io_rx_data_2_ lab=rx_data[2]}
C {devices/opin.sym} 5200 220 0 0 {name=io_rx_data_1_ lab=rx_data[1]}
C {devices/opin.sym} 5200 280 0 0 {name=io_rx_data_0_ lab=rx_data[0]}
C {devices/opin.sym} 5200 340 0 0 {name=io_rx_valid lab=rx_valid}
C {devices/opin.sym} 5200 400 0 0 {name=io_addr_match lab=addr_match}
C {devices/opin.sym} 5200 460 0 0 {name=io_rw lab=rw}
C {devices/opin.sym} 5200 520 0 0 {name=io_busy lab=busy}
