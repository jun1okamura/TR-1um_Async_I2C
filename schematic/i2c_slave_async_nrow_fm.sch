v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 1330 0 0 {name=x_135_}
C {devices/lab_pin.sym} 1480 1290 0 0 {name=l1 lab=VDD}
C {devices/lab_pin.sym} 1480 1370 0 0 {name=l2 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 570 0 0 {name=x_136_}
C {devices/lab_pin.sym} 1480 530 0 0 {name=l3 lab=VDD}
C {devices/lab_pin.sym} 1480 610 0 0 {name=l4 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 190 0 0 {name=x_137_}
C {devices/lab_pin.sym} 1480 150 0 0 {name=l5 lab=VDD}
C {devices/lab_pin.sym} 1480 230 0 0 {name=l6 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 0 0 0 {name=x_138_}
C {devices/lab_pin.sym} 1480 -40 0 0 {name=l7 lab=VDD}
C {devices/lab_pin.sym} 1480 40 0 0 {name=l8 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 380 0 0 {name=x_139_}
C {devices/lab_pin.sym} 1480 340 0 0 {name=l9 lab=VDD}
C {devices/lab_pin.sym} 1480 420 0 0 {name=l10 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 950 0 0 {name=x_140_}
C {devices/lab_pin.sym} 1480 910 0 0 {name=l11 lab=VDD}
C {devices/lab_pin.sym} 1480 990 0 0 {name=l12 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 1900 0 0 {name=x_141_}
C {devices/lab_pin.sym} 1480 1860 0 0 {name=l13 lab=VDD}
C {devices/lab_pin.sym} 1480 1940 0 0 {name=l14 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3100 2090 0 0 {name=x_142_}
C {devices/lab_pin.sym} 3130 2050 0 0 {name=l15 lab=VDD}
C {devices/lab_pin.sym} 3130 2130 0 0 {name=l16 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3100 3040 0 0 {name=x_143_}
C {devices/lab_pin.sym} 3130 2980 0 0 {name=l17 lab=VDD}
C {devices/lab_pin.sym} 3130 3100 0 0 {name=l18 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3650 2660 0 0 {name=x_144_}
C {devices/lab_pin.sym} 3680 2600 0 0 {name=l19 lab=VDD}
C {devices/lab_pin.sym} 3680 2720 0 0 {name=l20 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4200 1900 0 0 {name=x_145_}
C {devices/lab_pin.sym} 4230 1840 0 0 {name=l21 lab=VDD}
C {devices/lab_pin.sym} 4230 1960 0 0 {name=l22 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 5300 950 0 0 {name=x_146_}
C {devices/lab_pin.sym} 5330 890 0 0 {name=l23 lab=VDD}
C {devices/lab_pin.sym} 5330 1010 0 0 {name=l24 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1450 2090 0 0 {name=x_147_}
C {devices/lab_pin.sym} 1480 2030 0 0 {name=l25 lab=VDD}
C {devices/lab_pin.sym} 1480 2150 0 0 {name=l26 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 1140 0 0 {name=x_148_}
C {devices/lab_pin.sym} 2030 1080 0 0 {name=l27 lab=VDD}
C {devices/lab_pin.sym} 2030 1200 0 0 {name=l28 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 1450 760 0 0 {name=x_149_}
C {devices/lab_pin.sym} 1480 700 0 0 {name=l29 lab=VDD}
C {devices/lab_pin.sym} 1480 820 0 0 {name=l30 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 950 0 0 {name=x_150_}
C {devices/lab_pin.sym} 2030 890 0 0 {name=l31 lab=VDD}
C {devices/lab_pin.sym} 2030 1010 0 0 {name=l32 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1450 2280 0 0 {name=x_151_}
C {devices/lab_pin.sym} 1480 2220 0 0 {name=l33 lab=VDD}
C {devices/lab_pin.sym} 1480 2340 0 0 {name=l34 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 2090 0 0 {name=x_152_}
C {devices/lab_pin.sym} 2030 2030 0 0 {name=l35 lab=VDD}
C {devices/lab_pin.sym} 2030 2150 0 0 {name=l36 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2550 1710 0 0 {name=x_153_}
C {devices/lab_pin.sym} 2580 1670 0 0 {name=l37 lab=VDD}
C {devices/lab_pin.sym} 2580 1750 0 0 {name=l38 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 3610 0 0 {name=x_154_}
C {devices/lab_pin.sym} 2030 3550 0 0 {name=l39 lab=VDD}
C {devices/lab_pin.sym} 2030 3670 0 0 {name=l40 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 3800 0 0 {name=x_155_}
C {devices/lab_pin.sym} 2030 3740 0 0 {name=l41 lab=VDD}
C {devices/lab_pin.sym} 2030 3860 0 0 {name=l42 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 2550 1140 0 0 {name=x_156_}
C {devices/lab_pin.sym} 2580 1080 0 0 {name=l43 lab=VDD}
C {devices/lab_pin.sym} 2580 1200 0 0 {name=l44 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR3.sym} 2550 1520 0 0 {name=x_157_}
C {devices/lab_pin.sym} 2580 1460 0 0 {name=l45 lab=VDD}
C {devices/lab_pin.sym} 2580 1580 0 0 {name=l46 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 1450 1140 0 0 {name=x_158_}
C {devices/lab_pin.sym} 1480 1080 0 0 {name=l47 lab=VDD}
C {devices/lab_pin.sym} 1480 1200 0 0 {name=l48 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 3100 760 0 0 {name=x_159_}
C {devices/lab_pin.sym} 3130 700 0 0 {name=l49 lab=VDD}
C {devices/lab_pin.sym} 3130 820 0 0 {name=l50 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3650 1140 0 0 {name=x_160_}
C {devices/lab_pin.sym} 3680 1080 0 0 {name=l51 lab=VDD}
C {devices/lab_pin.sym} 3680 1200 0 0 {name=l52 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3650 1330 0 0 {name=x_161_}
C {devices/lab_pin.sym} 3680 1270 0 0 {name=l53 lab=VDD}
C {devices/lab_pin.sym} 3680 1390 0 0 {name=l54 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 760 0 0 {name=x_162_}
C {devices/lab_pin.sym} 4230 700 0 0 {name=l55 lab=VDD}
C {devices/lab_pin.sym} 4230 820 0 0 {name=l56 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1450 1710 0 0 {name=x_163_}
C {devices/lab_pin.sym} 1480 1650 0 0 {name=l57 lab=VDD}
C {devices/lab_pin.sym} 1480 1770 0 0 {name=l58 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 1900 0 0 {name=x_164_}
C {devices/lab_pin.sym} 2030 1840 0 0 {name=l59 lab=VDD}
C {devices/lab_pin.sym} 2030 1960 0 0 {name=l60 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 1710 0 0 {name=x_165_}
C {devices/lab_pin.sym} 2030 1650 0 0 {name=l61 lab=VDD}
C {devices/lab_pin.sym} 2030 1770 0 0 {name=l62 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 3100 1900 0 0 {name=x_166_}
C {devices/lab_pin.sym} 3130 1840 0 0 {name=l63 lab=VDD}
C {devices/lab_pin.sym} 3130 1960 0 0 {name=l64 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3650 950 0 0 {name=x_167_}
C {devices/lab_pin.sym} 3680 910 0 0 {name=l65 lab=VDD}
C {devices/lab_pin.sym} 3680 990 0 0 {name=l66 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4750 760 0 0 {name=x_168_}
C {devices/lab_pin.sym} 4780 700 0 0 {name=l67 lab=VDD}
C {devices/lab_pin.sym} 4780 820 0 0 {name=l68 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 950 0 0 {name=x_169_}
C {devices/lab_pin.sym} 4230 890 0 0 {name=l69 lab=VDD}
C {devices/lab_pin.sym} 4230 1010 0 0 {name=l70 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4750 950 0 0 {name=x_170_}
C {devices/lab_pin.sym} 4780 890 0 0 {name=l71 lab=VDD}
C {devices/lab_pin.sym} 4780 1010 0 0 {name=l72 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 5300 760 0 0 {name=x_171_}
C {devices/lab_pin.sym} 5330 700 0 0 {name=l73 lab=VDD}
C {devices/lab_pin.sym} 5330 820 0 0 {name=l74 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3650 1710 0 0 {name=x_172_}
C {devices/lab_pin.sym} 3680 1650 0 0 {name=l75 lab=VDD}
C {devices/lab_pin.sym} 3680 1770 0 0 {name=l76 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1450 1520 0 0 {name=x_173_}
C {devices/lab_pin.sym} 1480 1460 0 0 {name=l77 lab=VDD}
C {devices/lab_pin.sym} 1480 1580 0 0 {name=l78 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR3.sym} 4200 1140 0 0 {name=x_174_}
C {devices/lab_pin.sym} 4230 1080 0 0 {name=l79 lab=VDD}
C {devices/lab_pin.sym} 4230 1200 0 0 {name=l80 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4750 1140 0 0 {name=x_175_}
C {devices/lab_pin.sym} 4780 1080 0 0 {name=l81 lab=VDD}
C {devices/lab_pin.sym} 4780 1200 0 0 {name=l82 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3650 2850 0 0 {name=x_176_}
C {devices/lab_pin.sym} 3680 2790 0 0 {name=l83 lab=VDD}
C {devices/lab_pin.sym} 3680 2910 0 0 {name=l84 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3100 1520 0 0 {name=x_177_}
C {devices/lab_pin.sym} 3130 1460 0 0 {name=l85 lab=VDD}
C {devices/lab_pin.sym} 3130 1580 0 0 {name=l86 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 1710 0 0 {name=x_178_}
C {devices/lab_pin.sym} 4230 1650 0 0 {name=l87 lab=VDD}
C {devices/lab_pin.sym} 4230 1770 0 0 {name=l88 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2550 2280 0 0 {name=x_179_}
C {devices/lab_pin.sym} 2580 2220 0 0 {name=l89 lab=VDD}
C {devices/lab_pin.sym} 2580 2340 0 0 {name=l90 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 3990 0 0 {name=x_180_}
C {devices/lab_pin.sym} 3140 3950 0 0 {name=l91 lab=VDD}
C {devices/lab_pin.sym} 3140 4030 0 0 {name=l92 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 3610 0 0 {name=x_181_}
C {devices/lab_pin.sym} 3140 3570 0 0 {name=l93 lab=VDD}
C {devices/lab_pin.sym} 3140 3650 0 0 {name=l94 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 3420 0 0 {name=x_182_}
C {devices/lab_pin.sym} 3140 3380 0 0 {name=l95 lab=VDD}
C {devices/lab_pin.sym} 3140 3460 0 0 {name=l96 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 2470 0 0 {name=x_183_}
C {devices/lab_pin.sym} 3140 2430 0 0 {name=l97 lab=VDD}
C {devices/lab_pin.sym} 3140 2510 0 0 {name=l98 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 2280 0 0 {name=x_184_}
C {devices/lab_pin.sym} 3140 2240 0 0 {name=l99 lab=VDD}
C {devices/lab_pin.sym} 3140 2320 0 0 {name=l100 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 1330 0 0 {name=x_185_}
C {devices/lab_pin.sym} 3140 1290 0 0 {name=l101 lab=VDD}
C {devices/lab_pin.sym} 3140 1370 0 0 {name=l102 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 2850 0 0 {name=x_186_}
C {devices/lab_pin.sym} 3140 2810 0 0 {name=l103 lab=VDD}
C {devices/lab_pin.sym} 3140 2890 0 0 {name=l104 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1450 2660 0 0 {name=x_187_}
C {devices/lab_pin.sym} 1480 2600 0 0 {name=l105 lab=VDD}
C {devices/lab_pin.sym} 1480 2720 0 0 {name=l106 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 3420 0 0 {name=x_188_}
C {devices/lab_pin.sym} 2030 3360 0 0 {name=l107 lab=VDD}
C {devices/lab_pin.sym} 2030 3480 0 0 {name=l108 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 3100 2660 0 0 {name=x_189_}
C {devices/lab_pin.sym} 3130 2600 0 0 {name=l109 lab=VDD}
C {devices/lab_pin.sym} 3130 2720 0 0 {name=l110 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3650 3230 0 0 {name=x_190_}
C {devices/lab_pin.sym} 3690 3190 0 0 {name=l111 lab=VDD}
C {devices/lab_pin.sym} 3690 3270 0 0 {name=l112 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3650 3420 0 0 {name=x_191_}
C {devices/lab_pin.sym} 3690 3380 0 0 {name=l113 lab=VDD}
C {devices/lab_pin.sym} 3690 3460 0 0 {name=l114 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3650 3040 0 0 {name=x_192_}
C {devices/lab_pin.sym} 3690 3000 0 0 {name=l115 lab=VDD}
C {devices/lab_pin.sym} 3690 3080 0 0 {name=l116 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3650 2470 0 0 {name=x_193_}
C {devices/lab_pin.sym} 3690 2430 0 0 {name=l117 lab=VDD}
C {devices/lab_pin.sym} 3690 2510 0 0 {name=l118 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3650 2280 0 0 {name=x_194_}
C {devices/lab_pin.sym} 3690 2240 0 0 {name=l119 lab=VDD}
C {devices/lab_pin.sym} 3690 2320 0 0 {name=l120 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3650 1900 0 0 {name=x_195_}
C {devices/lab_pin.sym} 3690 1860 0 0 {name=l121 lab=VDD}
C {devices/lab_pin.sym} 3690 1940 0 0 {name=l122 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3650 1520 0 0 {name=x_196_}
C {devices/lab_pin.sym} 3690 1480 0 0 {name=l123 lab=VDD}
C {devices/lab_pin.sym} 3690 1560 0 0 {name=l124 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 760 0 0 {name=x_197_}
C {devices/lab_pin.sym} 2030 700 0 0 {name=l125 lab=VDD}
C {devices/lab_pin.sym} 2030 820 0 0 {name=l126 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 2550 190 0 0 {name=x_198_}
C {devices/lab_pin.sym} 2580 130 0 0 {name=l127 lab=VDD}
C {devices/lab_pin.sym} 2580 250 0 0 {name=l128 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2550 380 0 0 {name=x_199_}
C {devices/lab_pin.sym} 2580 320 0 0 {name=l129 lab=VDD}
C {devices/lab_pin.sym} 2580 440 0 0 {name=l130 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3100 190 0 0 {name=x_200_}
C {devices/lab_pin.sym} 3130 130 0 0 {name=l131 lab=VDD}
C {devices/lab_pin.sym} 3130 250 0 0 {name=l132 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 380 0 0 {name=x_201_}
C {devices/lab_pin.sym} 4230 320 0 0 {name=l133 lab=VDD}
C {devices/lab_pin.sym} 4230 440 0 0 {name=l134 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 4750 190 0 0 {name=x_202_}
C {devices/lab_pin.sym} 4780 130 0 0 {name=l135 lab=VDD}
C {devices/lab_pin.sym} 4780 250 0 0 {name=l136 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3650 380 0 0 {name=x_203_}
C {devices/lab_pin.sym} 3680 320 0 0 {name=l137 lab=VDD}
C {devices/lab_pin.sym} 3680 440 0 0 {name=l138 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 5300 190 0 0 {name=x_204_}
C {devices/lab_pin.sym} 5330 130 0 0 {name=l139 lab=VDD}
C {devices/lab_pin.sym} 5330 250 0 0 {name=l140 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3100 570 0 0 {name=x_205_}
C {devices/lab_pin.sym} 3130 510 0 0 {name=l141 lab=VDD}
C {devices/lab_pin.sym} 3130 630 0 0 {name=l142 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3650 760 0 0 {name=x_206_}
C {devices/lab_pin.sym} 3680 700 0 0 {name=l143 lab=VDD}
C {devices/lab_pin.sym} 3680 820 0 0 {name=l144 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 1330 0 0 {name=x_207_}
C {devices/lab_pin.sym} 2030 1270 0 0 {name=l145 lab=VDD}
C {devices/lab_pin.sym} 2030 1390 0 0 {name=l146 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 2550 760 0 0 {name=x_208_}
C {devices/lab_pin.sym} 2580 700 0 0 {name=l147 lab=VDD}
C {devices/lab_pin.sym} 2580 820 0 0 {name=l148 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 4750 380 0 0 {name=x_209_}
C {devices/lab_pin.sym} 4780 320 0 0 {name=l149 lab=VDD}
C {devices/lab_pin.sym} 4780 440 0 0 {name=l150 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 5300 380 0 0 {name=x_210_}
C {devices/lab_pin.sym} 5330 320 0 0 {name=l151 lab=VDD}
C {devices/lab_pin.sym} 5330 440 0 0 {name=l152 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2550 1900 0 0 {name=x_211_}
C {devices/lab_pin.sym} 2580 1840 0 0 {name=l153 lab=VDD}
C {devices/lab_pin.sym} 2580 1960 0 0 {name=l154 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 1710 0 0 {name=x_212_}
C {devices/lab_pin.sym} 3140 1670 0 0 {name=l155 lab=VDD}
C {devices/lab_pin.sym} 3140 1750 0 0 {name=l156 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3650 570 0 0 {name=x_213_}
C {devices/lab_pin.sym} 3680 510 0 0 {name=l157 lab=VDD}
C {devices/lab_pin.sym} 3680 630 0 0 {name=l158 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3650 3610 0 0 {name=x_214_}
C {devices/lab_pin.sym} 3690 3570 0 0 {name=l159 lab=VDD}
C {devices/lab_pin.sym} 3690 3650 0 0 {name=l160 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 3800 0 0 {name=x_215_}
C {devices/lab_pin.sym} 3140 3760 0 0 {name=l161 lab=VDD}
C {devices/lab_pin.sym} 3140 3840 0 0 {name=l162 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2000 0 0 0 {name=x_216_}
C {devices/lab_pin.sym} 2030 -60 0 0 {name=l163 lab=VDD}
C {devices/lab_pin.sym} 2030 60 0 0 {name=l164 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 190 0 0 {name=x_217_}
C {devices/lab_pin.sym} 2030 130 0 0 {name=l165 lab=VDD}
C {devices/lab_pin.sym} 2030 250 0 0 {name=l166 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 380 0 0 {name=x_218_}
C {devices/lab_pin.sym} 2030 320 0 0 {name=l167 lab=VDD}
C {devices/lab_pin.sym} 2030 440 0 0 {name=l168 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2000 570 0 0 {name=x_219_}
C {devices/lab_pin.sym} 2030 510 0 0 {name=l169 lab=VDD}
C {devices/lab_pin.sym} 2030 630 0 0 {name=l170 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND4.sym} 2550 0 0 0 {name=x_220_}
C {devices/lab_pin.sym} 2580 -60 0 0 {name=l171 lab=VDD}
C {devices/lab_pin.sym} 2580 60 0 0 {name=l172 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3100 0 0 0 {name=x_221_}
C {devices/lab_pin.sym} 3130 -60 0 0 {name=l173 lab=VDD}
C {devices/lab_pin.sym} 3130 60 0 0 {name=l174 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3650 0 0 0 {name=x_222_}
C {devices/lab_pin.sym} 3680 -60 0 0 {name=l175 lab=VDD}
C {devices/lab_pin.sym} 3680 60 0 0 {name=l176 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 2280 0 0 {name=x_223_}
C {devices/lab_pin.sym} 2030 2220 0 0 {name=l177 lab=VDD}
C {devices/lab_pin.sym} 2030 2340 0 0 {name=l178 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2000 2470 0 0 {name=x_224_}
C {devices/lab_pin.sym} 2030 2410 0 0 {name=l179 lab=VDD}
C {devices/lab_pin.sym} 2030 2530 0 0 {name=l180 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2000 2660 0 0 {name=x_225_}
C {devices/lab_pin.sym} 2030 2600 0 0 {name=l181 lab=VDD}
C {devices/lab_pin.sym} 2030 2720 0 0 {name=l182 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 2850 0 0 {name=x_226_}
C {devices/lab_pin.sym} 2030 2790 0 0 {name=l183 lab=VDD}
C {devices/lab_pin.sym} 2030 2910 0 0 {name=l184 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND4.sym} 2550 950 0 0 {name=x_227_}
C {devices/lab_pin.sym} 2580 890 0 0 {name=l185 lab=VDD}
C {devices/lab_pin.sym} 2580 1010 0 0 {name=l186 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3100 380 0 0 {name=x_228_}
C {devices/lab_pin.sym} 3130 320 0 0 {name=l187 lab=VDD}
C {devices/lab_pin.sym} 3130 440 0 0 {name=l188 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 3650 190 0 0 {name=x_229_}
C {devices/lab_pin.sym} 3680 130 0 0 {name=l189 lab=VDD}
C {devices/lab_pin.sym} 3680 250 0 0 {name=l190 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 0 0 0 {name=x_230_}
C {devices/lab_pin.sym} 4230 -60 0 0 {name=l191 lab=VDD}
C {devices/lab_pin.sym} 4230 60 0 0 {name=l192 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 4750 0 0 0 {name=x_231_}
C {devices/lab_pin.sym} 4780 -60 0 0 {name=l193 lab=VDD}
C {devices/lab_pin.sym} 4780 60 0 0 {name=l194 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 2550 570 0 0 {name=x_232_}
C {devices/lab_pin.sym} 2580 510 0 0 {name=l195 lab=VDD}
C {devices/lab_pin.sym} 2580 630 0 0 {name=l196 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 4200 190 0 0 {name=x_233_}
C {devices/lab_pin.sym} 4230 130 0 0 {name=l197 lab=VDD}
C {devices/lab_pin.sym} 4230 250 0 0 {name=l198 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 5300 0 0 0 {name=x_234_}
C {devices/lab_pin.sym} 5330 -60 0 0 {name=l199 lab=VDD}
C {devices/lab_pin.sym} 5330 60 0 0 {name=l200 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4200 570 0 0 {name=x_235_}
C {devices/lab_pin.sym} 4230 510 0 0 {name=l201 lab=VDD}
C {devices/lab_pin.sym} 4230 630 0 0 {name=l202 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 5300 570 0 0 {name=x_236_}
C {devices/lab_pin.sym} 5340 530 0 0 {name=l203 lab=VDD}
C {devices/lab_pin.sym} 5340 610 0 0 {name=l204 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 3650 2090 0 0 {name=x_237_}
C {devices/lab_pin.sym} 3680 2030 0 0 {name=l205 lab=VDD}
C {devices/lab_pin.sym} 3680 2150 0 0 {name=l206 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 1330 0 0 {name=x_238_}
C {devices/lab_pin.sym} 4230 1270 0 0 {name=l207 lab=VDD}
C {devices/lab_pin.sym} 4230 1390 0 0 {name=l208 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR4.sym} 1450 3040 0 0 {name=x_239_}
C {devices/lab_pin.sym} 1480 2980 0 0 {name=l209 lab=VDD}
C {devices/lab_pin.sym} 1480 3100 0 0 {name=l210 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 2000 4370 0 0 {name=x_240_}
C {devices/lab_pin.sym} 2030 4310 0 0 {name=l211 lab=VDD}
C {devices/lab_pin.sym} 2030 4430 0 0 {name=l212 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/MUX2.sym} 3100 3230 0 0 {name=x_241_}
C {devices/lab_pin.sym} 3140 3190 0 0 {name=l213 lab=VDD}
C {devices/lab_pin.sym} 3140 3270 0 0 {name=l214 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 570 0 0 {name=x_242_}
C {devices/lab_pin.sym} 4720 510 0 0 {name=l215 lab=VDD}
C {devices/lab_pin.sym} 4720 630 0 0 {name=l216 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 190 0 0 {name=x_243_}
C {devices/lab_pin.sym} 5820 130 0 0 {name=l217 lab=VDD}
C {devices/lab_pin.sym} 5820 250 0 0 {name=l218 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 380 0 0 {name=x_244_}
C {devices/lab_pin.sym} 5820 320 0 0 {name=l219 lab=VDD}
C {devices/lab_pin.sym} 5820 440 0 0 {name=l220 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 1710 0 0 {name=x_245_}
C {devices/lab_pin.sym} 4720 1650 0 0 {name=l221 lab=VDD}
C {devices/lab_pin.sym} 4720 1770 0 0 {name=l222 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 950 0 0 {name=x_246_}
C {devices/lab_pin.sym} 5820 890 0 0 {name=l223 lab=VDD}
C {devices/lab_pin.sym} 5820 1010 0 0 {name=l224 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 1140 0 0 {name=x_247_}
C {devices/lab_pin.sym} 5820 1080 0 0 {name=l225 lab=VDD}
C {devices/lab_pin.sym} 5820 1200 0 0 {name=l226 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 1330 0 0 {name=x_248_}
C {devices/lab_pin.sym} 5820 1270 0 0 {name=l227 lab=VDD}
C {devices/lab_pin.sym} 5820 1390 0 0 {name=l228 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 1520 0 0 {name=x_249_}
C {devices/lab_pin.sym} 5820 1460 0 0 {name=l229 lab=VDD}
C {devices/lab_pin.sym} 5820 1580 0 0 {name=l230 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 1710 0 0 {name=x_250_}
C {devices/lab_pin.sym} 5820 1650 0 0 {name=l231 lab=VDD}
C {devices/lab_pin.sym} 5820 1770 0 0 {name=l232 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 2090 0 0 {name=x_251_}
C {devices/lab_pin.sym} 5820 2030 0 0 {name=l233 lab=VDD}
C {devices/lab_pin.sym} 5820 2150 0 0 {name=l234 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 1900 0 0 {name=x_252_}
C {devices/lab_pin.sym} 5820 1840 0 0 {name=l235 lab=VDD}
C {devices/lab_pin.sym} 5820 1960 0 0 {name=l236 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 2280 0 0 {name=x_253_}
C {devices/lab_pin.sym} 5820 2220 0 0 {name=l237 lab=VDD}
C {devices/lab_pin.sym} 5820 2340 0 0 {name=l238 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 2470 0 0 {name=x_254_}
C {devices/lab_pin.sym} 4720 2410 0 0 {name=l239 lab=VDD}
C {devices/lab_pin.sym} 4720 2530 0 0 {name=l240 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 1520 0 0 {name=x_255_}
C {devices/lab_pin.sym} 4720 1460 0 0 {name=l241 lab=VDD}
C {devices/lab_pin.sym} 4720 1580 0 0 {name=l242 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 2090 0 0 {name=x_256_}
C {devices/lab_pin.sym} 4720 2030 0 0 {name=l243 lab=VDD}
C {devices/lab_pin.sym} 4720 2150 0 0 {name=l244 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 2280 0 0 {name=x_257_}
C {devices/lab_pin.sym} 4720 2220 0 0 {name=l245 lab=VDD}
C {devices/lab_pin.sym} 4720 2340 0 0 {name=l246 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 3230 0 0 {name=x_258_}
C {devices/lab_pin.sym} 4720 3170 0 0 {name=l247 lab=VDD}
C {devices/lab_pin.sym} 4720 3290 0 0 {name=l248 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 3800 0 0 {name=x_259_}
C {devices/lab_pin.sym} 4720 3740 0 0 {name=l249 lab=VDD}
C {devices/lab_pin.sym} 4720 3860 0 0 {name=l250 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 4560 0 0 {name=x_260_}
C {devices/lab_pin.sym} 4720 4500 0 0 {name=l251 lab=VDD}
C {devices/lab_pin.sym} 4720 4620 0 0 {name=l252 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 3990 0 0 {name=x_261_}
C {devices/lab_pin.sym} 4720 3930 0 0 {name=l253 lab=VDD}
C {devices/lab_pin.sym} 4720 4050 0 0 {name=l254 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 1900 0 0 {name=x_262_}
C {devices/lab_pin.sym} 4720 1840 0 0 {name=l255 lab=VDD}
C {devices/lab_pin.sym} 4720 1960 0 0 {name=l256 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5300 1140 0 0 {name=x_263_}
C {devices/lab_pin.sym} 5270 1080 0 0 {name=l257 lab=VDD}
C {devices/lab_pin.sym} 5270 1200 0 0 {name=l258 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 760 0 0 {name=x_264_}
C {devices/lab_pin.sym} 5820 700 0 0 {name=l259 lab=VDD}
C {devices/lab_pin.sym} 5820 820 0 0 {name=l260 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 570 0 0 {name=x_265_}
C {devices/lab_pin.sym} 5820 510 0 0 {name=l261 lab=VDD}
C {devices/lab_pin.sym} 5820 630 0 0 {name=l262 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 2660 0 0 {name=x_266_}
C {devices/lab_pin.sym} 4720 2600 0 0 {name=l263 lab=VDD}
C {devices/lab_pin.sym} 4720 2720 0 0 {name=l264 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 5850 0 0 0 {name=x_267_}
C {devices/lab_pin.sym} 5820 -60 0 0 {name=l265 lab=VDD}
C {devices/lab_pin.sym} 5820 60 0 0 {name=l266 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 3040 0 0 {name=x_268_}
C {devices/lab_pin.sym} 4720 2980 0 0 {name=l267 lab=VDD}
C {devices/lab_pin.sym} 4720 3100 0 0 {name=l268 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 3420 0 0 {name=x_269_}
C {devices/lab_pin.sym} 4720 3360 0 0 {name=l269 lab=VDD}
C {devices/lab_pin.sym} 4720 3480 0 0 {name=l270 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 2850 0 0 {name=x_270_}
C {devices/lab_pin.sym} 4720 2790 0 0 {name=l271 lab=VDD}
C {devices/lab_pin.sym} 4720 2910 0 0 {name=l272 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 4750 0 0 {name=x_271_}
C {devices/lab_pin.sym} 4720 4690 0 0 {name=l273 lab=VDD}
C {devices/lab_pin.sym} 4720 4810 0 0 {name=l274 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 4180 0 0 {name=x_272_}
C {devices/lab_pin.sym} 4720 4120 0 0 {name=l275 lab=VDD}
C {devices/lab_pin.sym} 4720 4240 0 0 {name=l276 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 4370 0 0 {name=x_273_}
C {devices/lab_pin.sym} 4720 4310 0 0 {name=l277 lab=VDD}
C {devices/lab_pin.sym} 4720 4430 0 0 {name=l278 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/DFFRB.sym} 4750 3610 0 0 {name=x_274_}
C {devices/lab_pin.sym} 4720 3550 0 0 {name=l279 lab=VDD}
C {devices/lab_pin.sym} 4720 3670 0 0 {name=l280 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DEL1.sym} 2550 2090 0 0 {name=xu_del_sda}
C {devices/lab_pin.sym} 2580 2050 0 0 {name=l281 lab=VDD}
C {devices/lab_pin.sym} 2580 2130 0 0 {name=l282 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2550 1330 0 0 {name=xu_inv_scl}
C {devices/lab_pin.sym} 2580 1290 0 0 {name=l283 lab=VDD}
C {devices/lab_pin.sym} 2580 1370 0 0 {name=l284 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4750 1330 0 0 {name=xu_lat_q}
C {devices/lab_pin.sym} 4780 1270 0 0 {name=l285 lab=VDD}
C {devices/lab_pin.sym} 4780 1390 0 0 {name=l286 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4200 1520 0 0 {name=xu_lat_qn}
C {devices/lab_pin.sym} 4230 1460 0 0 {name=l287 lab=VDD}
C {devices/lab_pin.sym} 4230 1580 0 0 {name=l288 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X1.sym} 2000 3040 0 0 {name=xu_buf_scl_row0}
C {devices/lab_pin.sym} 2030 3000 0 0 {name=l289 lab=VDD}
C {devices/lab_pin.sym} 2030 3080 0 0 {name=l290 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X1.sym} 2000 1520 0 0 {name=xu_buf_scl_row1}
C {devices/lab_pin.sym} 2030 1480 0 0 {name=l291 lab=VDD}
C {devices/lab_pin.sym} 2030 1560 0 0 {name=l292 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X1.sym} 2000 4180 0 0 {name=xu_buf_scl_row2}
C {devices/lab_pin.sym} 2030 4140 0 0 {name=l293 lab=VDD}
C {devices/lab_pin.sym} 2030 4220 0 0 {name=l294 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X1.sym} 2000 4560 0 0 {name=xu_buf_scl_row3}
C {devices/lab_pin.sym} 2030 4520 0 0 {name=l295 lab=VDD}
C {devices/lab_pin.sym} 2030 4600 0 0 {name=l296 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X1.sym} 3100 950 0 0 {name=xu_buf_scl_n_row1}
C {devices/lab_pin.sym} 3130 910 0 0 {name=l297 lab=VDD}
C {devices/lab_pin.sym} 3130 990 0 0 {name=l298 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X1.sym} 3100 1140 0 0 {name=xu_buf_scl_n_row2}
C {devices/lab_pin.sym} 3130 1100 0 0 {name=l299 lab=VDD}
C {devices/lab_pin.sym} 3130 1180 0 0 {name=l300 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/BUFTH.sym} 1450 2470 0 0 {name=xu_bufth_scl}
C {devices/lab_pin.sym} 1480 2430 0 0 {name=l301 lab=VDD}
C {devices/lab_pin.sym} 1480 2510 0 0 {name=l302 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/BUFTH.sym} 1450 2850 0 0 {name=xu_bufth_sda_in}
C {devices/lab_pin.sym} 1480 2810 0 0 {name=l303 lab=VDD}
C {devices/lab_pin.sym} 1480 2890 0 0 {name=l304 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X1.sym} 2000 3230 0 0 {name=xu_buf_sda_in_row0}
C {devices/lab_pin.sym} 2030 3190 0 0 {name=l305 lab=VDD}
C {devices/lab_pin.sym} 2030 3270 0 0 {name=l306 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/BUF_X1.sym} 2000 3990 0 0 {name=xu_buf_sda_in_row3}
C {devices/lab_pin.sym} 2030 3950 0 0 {name=l307 lab=VDD}
C {devices/lab_pin.sym} 2030 4030 0 0 {name=l308 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 6950 -600 0 0 {name=xFILLPRI_0_0}
C {devices/lab_pin.sym} 6950 -660 0 0 {name=l309 lab=VDD}
C {devices/lab_pin.sym} 6950 -540 0 0 {name=l310 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7100 -600 0 0 {name=xFILL_0_1}
C {devices/lab_pin.sym} 7100 -660 0 0 {name=l311 lab=VDD}
C {devices/lab_pin.sym} 7100 -540 0 0 {name=l312 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7250 -600 0 0 {name=xFILLPRI_1_2}
C {devices/lab_pin.sym} 7250 -660 0 0 {name=l313 lab=VDD}
C {devices/lab_pin.sym} 7250 -540 0 0 {name=l314 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7400 -600 0 0 {name=xFILLPRI_2_3}
C {devices/lab_pin.sym} 7400 -660 0 0 {name=l315 lab=VDD}
C {devices/lab_pin.sym} 7400 -540 0 0 {name=l316 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7550 -600 0 0 {name=xFILL_1_4}
C {devices/lab_pin.sym} 7550 -660 0 0 {name=l317 lab=VDD}
C {devices/lab_pin.sym} 7550 -540 0 0 {name=l318 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7700 -600 0 0 {name=xFILL_2_5}
C {devices/lab_pin.sym} 7700 -660 0 0 {name=l319 lab=VDD}
C {devices/lab_pin.sym} 7700 -540 0 0 {name=l320 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7850 -600 0 0 {name=xFILL_3_6}
C {devices/lab_pin.sym} 7850 -660 0 0 {name=l321 lab=VDD}
C {devices/lab_pin.sym} 7850 -540 0 0 {name=l322 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8000 -600 0 0 {name=xFILL_4_7}
C {devices/lab_pin.sym} 8000 -660 0 0 {name=l323 lab=VDD}
C {devices/lab_pin.sym} 8000 -540 0 0 {name=l324 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8150 -600 0 0 {name=xFILL_5_8}
C {devices/lab_pin.sym} 8150 -660 0 0 {name=l325 lab=VDD}
C {devices/lab_pin.sym} 8150 -540 0 0 {name=l326 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8300 -600 0 0 {name=xFILL_6_9}
C {devices/lab_pin.sym} 8300 -660 0 0 {name=l327 lab=VDD}
C {devices/lab_pin.sym} 8300 -540 0 0 {name=l328 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8450 -600 0 0 {name=xFILL_7_10}
C {devices/lab_pin.sym} 8450 -660 0 0 {name=l329 lab=VDD}
C {devices/lab_pin.sym} 8450 -540 0 0 {name=l330 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8600 -600 0 0 {name=xFILL_8_11}
C {devices/lab_pin.sym} 8600 -660 0 0 {name=l331 lab=VDD}
C {devices/lab_pin.sym} 8600 -540 0 0 {name=l332 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 6950 -400 0 0 {name=xFILL_9_12}
C {devices/lab_pin.sym} 6950 -460 0 0 {name=l333 lab=VDD}
C {devices/lab_pin.sym} 6950 -340 0 0 {name=l334 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7100 -400 0 0 {name=xFILL_10_13}
C {devices/lab_pin.sym} 7100 -460 0 0 {name=l335 lab=VDD}
C {devices/lab_pin.sym} 7100 -340 0 0 {name=l336 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7250 -400 0 0 {name=xFILL_11_14}
C {devices/lab_pin.sym} 7250 -460 0 0 {name=l337 lab=VDD}
C {devices/lab_pin.sym} 7250 -340 0 0 {name=l338 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7400 -400 0 0 {name=xFILL_12_15}
C {devices/lab_pin.sym} 7400 -460 0 0 {name=l339 lab=VDD}
C {devices/lab_pin.sym} 7400 -340 0 0 {name=l340 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7550 -400 0 0 {name=xFILL_13_16}
C {devices/lab_pin.sym} 7550 -460 0 0 {name=l341 lab=VDD}
C {devices/lab_pin.sym} 7550 -340 0 0 {name=l342 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7700 -400 0 0 {name=xFILL_14_17}
C {devices/lab_pin.sym} 7700 -460 0 0 {name=l343 lab=VDD}
C {devices/lab_pin.sym} 7700 -340 0 0 {name=l344 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7850 -400 0 0 {name=xFILL_15_18}
C {devices/lab_pin.sym} 7850 -460 0 0 {name=l345 lab=VDD}
C {devices/lab_pin.sym} 7850 -340 0 0 {name=l346 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8000 -400 0 0 {name=xFILL_16_19}
C {devices/lab_pin.sym} 8000 -460 0 0 {name=l347 lab=VDD}
C {devices/lab_pin.sym} 8000 -340 0 0 {name=l348 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8150 -400 0 0 {name=xFILL_17_20}
C {devices/lab_pin.sym} 8150 -460 0 0 {name=l349 lab=VDD}
C {devices/lab_pin.sym} 8150 -340 0 0 {name=l350 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8300 -400 0 0 {name=xFILL_18_21}
C {devices/lab_pin.sym} 8300 -460 0 0 {name=l351 lab=VDD}
C {devices/lab_pin.sym} 8300 -340 0 0 {name=l352 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8450 -400 0 0 {name=xFILL_19_22}
C {devices/lab_pin.sym} 8450 -460 0 0 {name=l353 lab=VDD}
C {devices/lab_pin.sym} 8450 -340 0 0 {name=l354 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8600 -400 0 0 {name=xFILL_20_23}
C {devices/lab_pin.sym} 8600 -460 0 0 {name=l355 lab=VDD}
C {devices/lab_pin.sym} 8600 -340 0 0 {name=l356 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 6950 -200 0 0 {name=xFILL_21_24}
C {devices/lab_pin.sym} 6950 -260 0 0 {name=l357 lab=VDD}
C {devices/lab_pin.sym} 6950 -140 0 0 {name=l358 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7100 -200 0 0 {name=xFILL_22_25}
C {devices/lab_pin.sym} 7100 -260 0 0 {name=l359 lab=VDD}
C {devices/lab_pin.sym} 7100 -140 0 0 {name=l360 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7250 -200 0 0 {name=xFILL_23_26}
C {devices/lab_pin.sym} 7250 -260 0 0 {name=l361 lab=VDD}
C {devices/lab_pin.sym} 7250 -140 0 0 {name=l362 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7400 -200 0 0 {name=xFILL_24_27}
C {devices/lab_pin.sym} 7400 -260 0 0 {name=l363 lab=VDD}
C {devices/lab_pin.sym} 7400 -140 0 0 {name=l364 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7550 -200 0 0 {name=xFILL_25_28}
C {devices/lab_pin.sym} 7550 -260 0 0 {name=l365 lab=VDD}
C {devices/lab_pin.sym} 7550 -140 0 0 {name=l366 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7700 -200 0 0 {name=xFILLPRI_3_29}
C {devices/lab_pin.sym} 7700 -260 0 0 {name=l367 lab=VDD}
C {devices/lab_pin.sym} 7700 -140 0 0 {name=l368 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7850 -200 0 0 {name=xFILLPRI_0_30}
C {devices/lab_pin.sym} 7850 -260 0 0 {name=l369 lab=VDD}
C {devices/lab_pin.sym} 7850 -140 0 0 {name=l370 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8000 -200 0 0 {name=xFILL_0_31}
C {devices/lab_pin.sym} 8000 -260 0 0 {name=l371 lab=VDD}
C {devices/lab_pin.sym} 8000 -140 0 0 {name=l372 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8150 -200 0 0 {name=xFILL_1_32}
C {devices/lab_pin.sym} 8150 -260 0 0 {name=l373 lab=VDD}
C {devices/lab_pin.sym} 8150 -140 0 0 {name=l374 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8300 -200 0 0 {name=xFILL_2_33}
C {devices/lab_pin.sym} 8300 -260 0 0 {name=l375 lab=VDD}
C {devices/lab_pin.sym} 8300 -140 0 0 {name=l376 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8450 -200 0 0 {name=xFILL_3_34}
C {devices/lab_pin.sym} 8450 -260 0 0 {name=l377 lab=VDD}
C {devices/lab_pin.sym} 8450 -140 0 0 {name=l378 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8600 -200 0 0 {name=xFILL_4_35}
C {devices/lab_pin.sym} 8600 -260 0 0 {name=l379 lab=VDD}
C {devices/lab_pin.sym} 8600 -140 0 0 {name=l380 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 6950 0 0 0 {name=xFILL_5_36}
C {devices/lab_pin.sym} 6950 -60 0 0 {name=l381 lab=VDD}
C {devices/lab_pin.sym} 6950 60 0 0 {name=l382 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7100 0 0 0 {name=xFILL_6_37}
C {devices/lab_pin.sym} 7100 -60 0 0 {name=l383 lab=VDD}
C {devices/lab_pin.sym} 7100 60 0 0 {name=l384 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7250 0 0 0 {name=xFILL_7_38}
C {devices/lab_pin.sym} 7250 -60 0 0 {name=l385 lab=VDD}
C {devices/lab_pin.sym} 7250 60 0 0 {name=l386 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7400 0 0 0 {name=xFILL_8_39}
C {devices/lab_pin.sym} 7400 -60 0 0 {name=l387 lab=VDD}
C {devices/lab_pin.sym} 7400 60 0 0 {name=l388 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7550 0 0 0 {name=xFILL_9_40}
C {devices/lab_pin.sym} 7550 -60 0 0 {name=l389 lab=VDD}
C {devices/lab_pin.sym} 7550 60 0 0 {name=l390 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7700 0 0 0 {name=xFILL_10_41}
C {devices/lab_pin.sym} 7700 -60 0 0 {name=l391 lab=VDD}
C {devices/lab_pin.sym} 7700 60 0 0 {name=l392 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7850 0 0 0 {name=xFILL_11_42}
C {devices/lab_pin.sym} 7850 -60 0 0 {name=l393 lab=VDD}
C {devices/lab_pin.sym} 7850 60 0 0 {name=l394 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8000 0 0 0 {name=xFILL_12_43}
C {devices/lab_pin.sym} 8000 -60 0 0 {name=l395 lab=VDD}
C {devices/lab_pin.sym} 8000 60 0 0 {name=l396 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8150 0 0 0 {name=xFILL_13_44}
C {devices/lab_pin.sym} 8150 -60 0 0 {name=l397 lab=VDD}
C {devices/lab_pin.sym} 8150 60 0 0 {name=l398 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8300 0 0 0 {name=xFILL_14_45}
C {devices/lab_pin.sym} 8300 -60 0 0 {name=l399 lab=VDD}
C {devices/lab_pin.sym} 8300 60 0 0 {name=l400 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8450 0 0 0 {name=xFILL_15_46}
C {devices/lab_pin.sym} 8450 -60 0 0 {name=l401 lab=VDD}
C {devices/lab_pin.sym} 8450 60 0 0 {name=l402 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8600 0 0 0 {name=xFILL_16_47}
C {devices/lab_pin.sym} 8600 -60 0 0 {name=l403 lab=VDD}
C {devices/lab_pin.sym} 8600 60 0 0 {name=l404 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 6950 200 0 0 {name=xFILL_17_48}
C {devices/lab_pin.sym} 6950 140 0 0 {name=l405 lab=VDD}
C {devices/lab_pin.sym} 6950 260 0 0 {name=l406 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7100 200 0 0 {name=xFILLPRI_1_49}
C {devices/lab_pin.sym} 7100 140 0 0 {name=l407 lab=VDD}
C {devices/lab_pin.sym} 7100 260 0 0 {name=l408 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7250 200 0 0 {name=xFILLPRI_2_50}
C {devices/lab_pin.sym} 7250 140 0 0 {name=l409 lab=VDD}
C {devices/lab_pin.sym} 7250 260 0 0 {name=l410 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7400 200 0 0 {name=xFILL_18_51}
C {devices/lab_pin.sym} 7400 140 0 0 {name=l411 lab=VDD}
C {devices/lab_pin.sym} 7400 260 0 0 {name=l412 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7550 200 0 0 {name=xFILL_19_52}
C {devices/lab_pin.sym} 7550 140 0 0 {name=l413 lab=VDD}
C {devices/lab_pin.sym} 7550 260 0 0 {name=l414 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7700 200 0 0 {name=xFILLPRI_3_53}
C {devices/lab_pin.sym} 7700 140 0 0 {name=l415 lab=VDD}
C {devices/lab_pin.sym} 7700 260 0 0 {name=l416 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7850 200 0 0 {name=xFILLPRI_0_54}
C {devices/lab_pin.sym} 7850 140 0 0 {name=l417 lab=VDD}
C {devices/lab_pin.sym} 7850 260 0 0 {name=l418 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 8000 200 0 0 {name=xFILLPRI_1_55}
C {devices/lab_pin.sym} 8000 140 0 0 {name=l419 lab=VDD}
C {devices/lab_pin.sym} 8000 260 0 0 {name=l420 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 8150 200 0 0 {name=xFILLPRI_2_56}
C {devices/lab_pin.sym} 8150 140 0 0 {name=l421 lab=VDD}
C {devices/lab_pin.sym} 8150 260 0 0 {name=l422 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8300 200 0 0 {name=xFILL_0_57}
C {devices/lab_pin.sym} 8300 140 0 0 {name=l423 lab=VDD}
C {devices/lab_pin.sym} 8300 260 0 0 {name=l424 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8450 200 0 0 {name=xFILL_1_58}
C {devices/lab_pin.sym} 8450 140 0 0 {name=l425 lab=VDD}
C {devices/lab_pin.sym} 8450 260 0 0 {name=l426 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8600 200 0 0 {name=xFILL_2_59}
C {devices/lab_pin.sym} 8600 140 0 0 {name=l427 lab=VDD}
C {devices/lab_pin.sym} 8600 260 0 0 {name=l428 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 6950 400 0 0 {name=xFILL_3_60}
C {devices/lab_pin.sym} 6950 340 0 0 {name=l429 lab=VDD}
C {devices/lab_pin.sym} 6950 460 0 0 {name=l430 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7100 400 0 0 {name=xFILL_4_61}
C {devices/lab_pin.sym} 7100 340 0 0 {name=l431 lab=VDD}
C {devices/lab_pin.sym} 7100 460 0 0 {name=l432 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7250 400 0 0 {name=xFILL_5_62}
C {devices/lab_pin.sym} 7250 340 0 0 {name=l433 lab=VDD}
C {devices/lab_pin.sym} 7250 460 0 0 {name=l434 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7400 400 0 0 {name=xFILL_6_63}
C {devices/lab_pin.sym} 7400 340 0 0 {name=l435 lab=VDD}
C {devices/lab_pin.sym} 7400 460 0 0 {name=l436 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7550 400 0 0 {name=xFILL_7_64}
C {devices/lab_pin.sym} 7550 340 0 0 {name=l437 lab=VDD}
C {devices/lab_pin.sym} 7550 460 0 0 {name=l438 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7700 400 0 0 {name=xFILL_8_65}
C {devices/lab_pin.sym} 7700 340 0 0 {name=l439 lab=VDD}
C {devices/lab_pin.sym} 7700 460 0 0 {name=l440 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7850 400 0 0 {name=xFILL_9_66}
C {devices/lab_pin.sym} 7850 340 0 0 {name=l441 lab=VDD}
C {devices/lab_pin.sym} 7850 460 0 0 {name=l442 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8000 400 0 0 {name=xFILL_10_67}
C {devices/lab_pin.sym} 8000 340 0 0 {name=l443 lab=VDD}
C {devices/lab_pin.sym} 8000 460 0 0 {name=l444 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8150 400 0 0 {name=xFILL_11_68}
C {devices/lab_pin.sym} 8150 340 0 0 {name=l445 lab=VDD}
C {devices/lab_pin.sym} 8150 460 0 0 {name=l446 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8300 400 0 0 {name=xFILL_12_69}
C {devices/lab_pin.sym} 8300 340 0 0 {name=l447 lab=VDD}
C {devices/lab_pin.sym} 8300 460 0 0 {name=l448 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8450 400 0 0 {name=xFILL_13_70}
C {devices/lab_pin.sym} 8450 340 0 0 {name=l449 lab=VDD}
C {devices/lab_pin.sym} 8450 460 0 0 {name=l450 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8600 400 0 0 {name=xFILL_14_71}
C {devices/lab_pin.sym} 8600 340 0 0 {name=l451 lab=VDD}
C {devices/lab_pin.sym} 8600 460 0 0 {name=l452 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 6950 600 0 0 {name=xFILL_15_72}
C {devices/lab_pin.sym} 6950 540 0 0 {name=l453 lab=VDD}
C {devices/lab_pin.sym} 6950 660 0 0 {name=l454 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7100 600 0 0 {name=xFILL_16_73}
C {devices/lab_pin.sym} 7100 540 0 0 {name=l455 lab=VDD}
C {devices/lab_pin.sym} 7100 660 0 0 {name=l456 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7250 600 0 0 {name=xFILL_17_74}
C {devices/lab_pin.sym} 7250 540 0 0 {name=l457 lab=VDD}
C {devices/lab_pin.sym} 7250 660 0 0 {name=l458 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7400 600 0 0 {name=xFILL_18_75}
C {devices/lab_pin.sym} 7400 540 0 0 {name=l459 lab=VDD}
C {devices/lab_pin.sym} 7400 660 0 0 {name=l460 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7550 600 0 0 {name=xFILL_19_76}
C {devices/lab_pin.sym} 7550 540 0 0 {name=l461 lab=VDD}
C {devices/lab_pin.sym} 7550 660 0 0 {name=l462 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7700 600 0 0 {name=xFILL_20_77}
C {devices/lab_pin.sym} 7700 540 0 0 {name=l463 lab=VDD}
C {devices/lab_pin.sym} 7700 660 0 0 {name=l464 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7850 600 0 0 {name=xFILL_21_78}
C {devices/lab_pin.sym} 7850 540 0 0 {name=l465 lab=VDD}
C {devices/lab_pin.sym} 7850 660 0 0 {name=l466 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8000 600 0 0 {name=xFILL_22_79}
C {devices/lab_pin.sym} 8000 540 0 0 {name=l467 lab=VDD}
C {devices/lab_pin.sym} 8000 660 0 0 {name=l468 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 8150 600 0 0 {name=xFILL_23_80}
C {devices/lab_pin.sym} 8150 540 0 0 {name=l469 lab=VDD}
C {devices/lab_pin.sym} 8150 660 0 0 {name=l470 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 8300 600 0 0 {name=xFILLPRI_3_81}
C {devices/lab_pin.sym} 8300 540 0 0 {name=l471 lab=VDD}
C {devices/lab_pin.sym} 8300 660 0 0 {name=l472 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 8450 600 0 0 {name=xFILLPRI_0_82}
C {devices/lab_pin.sym} 8450 540 0 0 {name=l473 lab=VDD}
C {devices/lab_pin.sym} 8450 660 0 0 {name=l474 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8600 600 0 0 {name=xFILL_0_83}
C {devices/lab_pin.sym} 8600 540 0 0 {name=l475 lab=VDD}
C {devices/lab_pin.sym} 8600 660 0 0 {name=l476 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 6950 800 0 0 {name=xFILL_1_84}
C {devices/lab_pin.sym} 6950 740 0 0 {name=l477 lab=VDD}
C {devices/lab_pin.sym} 6950 860 0 0 {name=l478 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7100 800 0 0 {name=xFILL_2_85}
C {devices/lab_pin.sym} 7100 740 0 0 {name=l479 lab=VDD}
C {devices/lab_pin.sym} 7100 860 0 0 {name=l480 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7250 800 0 0 {name=xFILL_3_86}
C {devices/lab_pin.sym} 7250 740 0 0 {name=l481 lab=VDD}
C {devices/lab_pin.sym} 7250 860 0 0 {name=l482 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7400 800 0 0 {name=xFILL_4_87}
C {devices/lab_pin.sym} 7400 740 0 0 {name=l483 lab=VDD}
C {devices/lab_pin.sym} 7400 860 0 0 {name=l484 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7550 800 0 0 {name=xFILL_5_88}
C {devices/lab_pin.sym} 7550 740 0 0 {name=l485 lab=VDD}
C {devices/lab_pin.sym} 7550 860 0 0 {name=l486 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7700 800 0 0 {name=xFILL_6_89}
C {devices/lab_pin.sym} 7700 740 0 0 {name=l487 lab=VDD}
C {devices/lab_pin.sym} 7700 860 0 0 {name=l488 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7850 800 0 0 {name=xFILL_7_90}
C {devices/lab_pin.sym} 7850 740 0 0 {name=l489 lab=VDD}
C {devices/lab_pin.sym} 7850 860 0 0 {name=l490 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8000 800 0 0 {name=xFILL_8_91}
C {devices/lab_pin.sym} 8000 740 0 0 {name=l491 lab=VDD}
C {devices/lab_pin.sym} 8000 860 0 0 {name=l492 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8150 800 0 0 {name=xFILL_9_92}
C {devices/lab_pin.sym} 8150 740 0 0 {name=l493 lab=VDD}
C {devices/lab_pin.sym} 8150 860 0 0 {name=l494 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8300 800 0 0 {name=xFILL_10_93}
C {devices/lab_pin.sym} 8300 740 0 0 {name=l495 lab=VDD}
C {devices/lab_pin.sym} 8300 860 0 0 {name=l496 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8450 800 0 0 {name=xFILL_11_94}
C {devices/lab_pin.sym} 8450 740 0 0 {name=l497 lab=VDD}
C {devices/lab_pin.sym} 8450 860 0 0 {name=l498 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8600 800 0 0 {name=xFILL_12_95}
C {devices/lab_pin.sym} 8600 740 0 0 {name=l499 lab=VDD}
C {devices/lab_pin.sym} 8600 860 0 0 {name=l500 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 6950 1000 0 0 {name=xFILL_13_96}
C {devices/lab_pin.sym} 6950 940 0 0 {name=l501 lab=VDD}
C {devices/lab_pin.sym} 6950 1060 0 0 {name=l502 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7100 1000 0 0 {name=xFILL_14_97}
C {devices/lab_pin.sym} 7100 940 0 0 {name=l503 lab=VDD}
C {devices/lab_pin.sym} 7100 1060 0 0 {name=l504 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7250 1000 0 0 {name=xFILL_15_98}
C {devices/lab_pin.sym} 7250 940 0 0 {name=l505 lab=VDD}
C {devices/lab_pin.sym} 7250 1060 0 0 {name=l506 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7400 1000 0 0 {name=xFILL_16_99}
C {devices/lab_pin.sym} 7400 940 0 0 {name=l507 lab=VDD}
C {devices/lab_pin.sym} 7400 1060 0 0 {name=l508 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7550 1000 0 0 {name=xFILL_17_100}
C {devices/lab_pin.sym} 7550 940 0 0 {name=l509 lab=VDD}
C {devices/lab_pin.sym} 7550 1060 0 0 {name=l510 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7700 1000 0 0 {name=xFILL_18_101}
C {devices/lab_pin.sym} 7700 940 0 0 {name=l511 lab=VDD}
C {devices/lab_pin.sym} 7700 1060 0 0 {name=l512 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7850 1000 0 0 {name=xFILL_19_102}
C {devices/lab_pin.sym} 7850 940 0 0 {name=l513 lab=VDD}
C {devices/lab_pin.sym} 7850 1060 0 0 {name=l514 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8000 1000 0 0 {name=xFILL_20_103}
C {devices/lab_pin.sym} 8000 940 0 0 {name=l515 lab=VDD}
C {devices/lab_pin.sym} 8000 1060 0 0 {name=l516 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8150 1000 0 0 {name=xFILL_21_104}
C {devices/lab_pin.sym} 8150 940 0 0 {name=l517 lab=VDD}
C {devices/lab_pin.sym} 8150 1060 0 0 {name=l518 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8300 1000 0 0 {name=xFILL_22_105}
C {devices/lab_pin.sym} 8300 940 0 0 {name=l519 lab=VDD}
C {devices/lab_pin.sym} 8300 1060 0 0 {name=l520 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 8450 1000 0 0 {name=xFILL_23_106}
C {devices/lab_pin.sym} 8450 940 0 0 {name=l521 lab=VDD}
C {devices/lab_pin.sym} 8450 1060 0 0 {name=l522 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 8600 1000 0 0 {name=xFILLPRI_1_107}
C {devices/lab_pin.sym} 8600 940 0 0 {name=l523 lab=VDD}
C {devices/lab_pin.sym} 8600 1060 0 0 {name=l524 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 6950 1200 0 0 {name=xFILLPRI_2_108}
C {devices/lab_pin.sym} 6950 1140 0 0 {name=l525 lab=VDD}
C {devices/lab_pin.sym} 6950 1260 0 0 {name=l526 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7100 1200 0 0 {name=xFILL_24_109}
C {devices/lab_pin.sym} 7100 1140 0 0 {name=l527 lab=VDD}
C {devices/lab_pin.sym} 7100 1260 0 0 {name=l528 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7250 1200 0 0 {name=xFILL_25_110}
C {devices/lab_pin.sym} 7250 1140 0 0 {name=l529 lab=VDD}
C {devices/lab_pin.sym} 7250 1260 0 0 {name=l530 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL3.sym} 7400 1200 0 0 {name=xFILL_26_111}
C {devices/lab_pin.sym} 7400 1140 0 0 {name=l531 lab=VDD}
C {devices/lab_pin.sym} 7400 1260 0 0 {name=l532 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7550 1200 0 0 {name=xFILL_27_112}
C {devices/lab_pin.sym} 7550 1140 0 0 {name=l533 lab=VDD}
C {devices/lab_pin.sym} 7550 1260 0 0 {name=l534 lab=GND}
C {/Users/okamura/Dropbox/98_LSI_Design/TR-1um_Async_I2C/LEF/FILL2.sym} 7700 1200 0 0 {name=xFILLPRI_3_113}
C {devices/lab_pin.sym} 7700 1140 0 0 {name=l535 lab=VDD}
C {devices/lab_pin.sym} 7700 1260 0 0 {name=l536 lab=GND}
C {devices/ipin.sym} 350 0 0 0 {name=io_rst_n lab=rst_n}
C {devices/ipin.sym} 350 950 0 0 {name=io_scl lab=scl}
C {devices/ipin.sym} 350 1330 0 0 {name=io_sda_in lab=sda_in}
C {devices/ipin.sym} 350 190 0 0 {name=io_tx_data_0_ lab=tx_data[0]}
C {devices/ipin.sym} 350 380 0 0 {name=io_tx_data_1_ lab=tx_data[1]}
C {devices/ipin.sym} 350 760 0 0 {name=io_tx_data_2_ lab=tx_data[2]}
C {devices/ipin.sym} 350 1140 0 0 {name=io_tx_data_3_ lab=tx_data[3]}
C {devices/ipin.sym} 350 1520 0 0 {name=io_tx_data_4_ lab=tx_data[4]}
C {devices/ipin.sym} 350 1900 0 0 {name=io_tx_data_5_ lab=tx_data[5]}
C {devices/ipin.sym} 350 1710 0 0 {name=io_tx_data_6_ lab=tx_data[6]}
C {devices/ipin.sym} 350 570 0 0 {name=io_tx_data_7_ lab=tx_data[7]}
C {devices/opin.sym} 6400 0 0 0 {name=io_sda_oe lab=sda_oe}
C {devices/opin.sym} 6400 1330 0 0 {name=io_rx_data_0_ lab=rx_data[0]}
C {devices/opin.sym} 6400 570 0 0 {name=io_rx_data_1_ lab=rx_data[1]}
C {devices/opin.sym} 6400 950 0 0 {name=io_rx_data_2_ lab=rx_data[2]}
C {devices/opin.sym} 6400 1140 0 0 {name=io_rx_data_3_ lab=rx_data[3]}
C {devices/opin.sym} 6400 1710 0 0 {name=io_rx_data_4_ lab=rx_data[4]}
C {devices/opin.sym} 6400 1900 0 0 {name=io_rx_data_5_ lab=rx_data[5]}
C {devices/opin.sym} 6400 2280 0 0 {name=io_rx_data_6_ lab=rx_data[6]}
C {devices/opin.sym} 6400 2090 0 0 {name=io_rx_data_7_ lab=rx_data[7]}
C {devices/opin.sym} 6400 190 0 0 {name=io_rx_valid lab=rx_valid}
C {devices/opin.sym} 6400 1520 0 0 {name=io_addr_match lab=addr_match}
C {devices/opin.sym} 6400 760 0 0 {name=io_rw lab=rw}
C {devices/opin.sym} 6400 380 0 0 {name=io_busy lab=busy}
C {devices/iopin.sym} 350 -260 0 0 {name=io_VDD lab=VDD}
C {devices/iopin.sym} 350 -200 0 0 {name=io_GND lab=GND}
C {devices/lab_pin.sym} 4310 1900 0 0 {name=l537 lab=RSTB1}
C {devices/lab_pin.sym} 4750 610 0 0 {name=l538 lab=RSTB1}
C {devices/lab_pin.sym} 5850 230 0 0 {name=l539 lab=RSTB1}
C {devices/lab_pin.sym} 5850 420 0 0 {name=l540 lab=RSTB1}
C {devices/lab_pin.sym} 4750 1750 0 0 {name=l541 lab=RSTB1}
C {devices/lab_pin.sym} 4750 2510 0 0 {name=l542 lab=RSTB1}
C {devices/lab_pin.sym} 4750 1560 0 0 {name=l543 lab=RSTB1}
C {devices/lab_pin.sym} 4750 2130 0 0 {name=l544 lab=RSTB1}
C {devices/lab_pin.sym} 4750 2320 0 0 {name=l545 lab=RSTB1}
C {devices/lab_pin.sym} 4750 3270 0 0 {name=l546 lab=RSTB1}
C {devices/lab_pin.sym} 4750 3840 0 0 {name=l547 lab=RSTB1}
C {devices/lab_pin.sym} 4750 4600 0 0 {name=l548 lab=RSTB1}
C {devices/lab_pin.sym} 4750 4030 0 0 {name=l549 lab=RSTB1}
C {devices/lab_pin.sym} 4750 1940 0 0 {name=l550 lab=RSTB1}
C {devices/lab_pin.sym} 5300 1180 0 0 {name=l551 lab=RSTB1}
C {devices/lab_pin.sym} 5850 800 0 0 {name=l552 lab=RSTB1}
C {devices/lab_pin.sym} 5850 610 0 0 {name=l553 lab=RSTB1}
C {devices/lab_pin.sym} 4750 2700 0 0 {name=l554 lab=RSTB1}
C {devices/lab_pin.sym} 4750 3080 0 0 {name=l555 lab=RSTB1}
C {devices/lab_pin.sym} 4750 3460 0 0 {name=l556 lab=RSTB1}
C {devices/lab_pin.sym} 4750 2890 0 0 {name=l557 lab=RSTB1}
C {devices/lab_pin.sym} 4750 4790 0 0 {name=l558 lab=RSTB1}
C {devices/lab_pin.sym} 4750 4220 0 0 {name=l559 lab=RSTB1}
C {devices/lab_pin.sym} 4750 4410 0 0 {name=l560 lab=RSTB1}
C {devices/lab_pin.sym} 4750 3650 0 0 {name=l561 lab=RSTB1}
C {devices/lab_pin.sym} 5410 950 0 0 {name=l562 lab=RSTB2}
C {devices/lab_pin.sym} 5850 990 0 0 {name=l563 lab=RSTB2}
C {devices/lab_pin.sym} 5850 1180 0 0 {name=l564 lab=RSTB2}
C {devices/lab_pin.sym} 5850 1370 0 0 {name=l565 lab=RSTB2}
C {devices/lab_pin.sym} 5850 1560 0 0 {name=l566 lab=RSTB2}
C {devices/lab_pin.sym} 5850 1750 0 0 {name=l567 lab=RSTB2}
C {devices/lab_pin.sym} 5850 2130 0 0 {name=l568 lab=RSTB2}
C {devices/lab_pin.sym} 5850 1940 0 0 {name=l569 lab=RSTB2}
C {devices/lab_pin.sym} 5850 2320 0 0 {name=l570 lab=RSTB2}
C {devices/lab_pin.sym} 5850 40 0 0 {name=l571 lab=RSTB2}
C {devices/lab_pin.sym} 5430 0 0 0 {name=l572 lab=_000_}
C {devices/lab_pin.sym} 5820 -30 0 0 {name=l573 lab=_000_}
C {devices/lab_pin.sym} 4780 580 0 0 {name=l574 lab=_001_}
C {devices/lab_pin.sym} 1980 1120 0 0 {name=l575 lab=_001_}
C {devices/lab_pin.sym} 1430 1690 0 0 {name=l576 lab=_001_}
C {devices/lab_pin.sym} 4780 3620 0 0 {name=l577 lab=_002_}
C {devices/lab_pin.sym} 1440 3010 0 0 {name=l578 lab=_002_}
C {devices/lab_pin.sym} 4780 4190 0 0 {name=l579 lab=_003_}
C {devices/lab_pin.sym} 1440 3030 0 0 {name=l580 lab=_003_}
C {devices/lab_pin.sym} 5880 200 0 0 {name=l581 lab=_004_}
C {devices/lab_pin.sym} 1430 2110 0 0 {name=l582 lab=_004_}
C {devices/lab_pin.sym} 5880 390 0 0 {name=l583 lab=_005_}
C {devices/lab_pin.sym} 1980 2070 0 0 {name=l584 lab=_005_}
C {devices/lab_pin.sym} 1980 1880 0 0 {name=l585 lab=_005_}
C {devices/lab_pin.sym} 4780 1720 0 0 {name=l586 lab=_006_}
C {devices/lab_pin.sym} 1430 380 0 0 {name=l587 lab=_006_}
C {devices/lab_pin.sym} 5410 760 0 0 {name=l588 lab=_009_}
C {devices/lab_pin.sym} 5820 730 0 0 {name=l589 lab=_009_}
C {devices/lab_pin.sym} 4880 1140 0 0 {name=l590 lab=_010_}
C {devices/lab_pin.sym} 5270 1110 0 0 {name=l591 lab=_010_}
C {devices/lab_pin.sym} 4330 1710 0 0 {name=l592 lab=_011_}
C {devices/lab_pin.sym} 4720 1870 0 0 {name=l593 lab=_011_}
C {devices/lab_pin.sym} 3170 3990 0 0 {name=l594 lab=_012_}
C {devices/lab_pin.sym} 4720 4530 0 0 {name=l595 lab=_012_}
C {devices/lab_pin.sym} 3170 3610 0 0 {name=l596 lab=_013_}
C {devices/lab_pin.sym} 4720 3770 0 0 {name=l597 lab=_013_}
C {devices/lab_pin.sym} 3170 3420 0 0 {name=l598 lab=_014_}
C {devices/lab_pin.sym} 4720 3200 0 0 {name=l599 lab=_014_}
C {devices/lab_pin.sym} 3170 2470 0 0 {name=l600 lab=_015_}
C {devices/lab_pin.sym} 4720 2250 0 0 {name=l601 lab=_015_}
C {devices/lab_pin.sym} 3170 2280 0 0 {name=l602 lab=_016_}
C {devices/lab_pin.sym} 4720 2060 0 0 {name=l603 lab=_016_}
C {devices/lab_pin.sym} 3170 1330 0 0 {name=l604 lab=_017_}
C {devices/lab_pin.sym} 4720 1490 0 0 {name=l605 lab=_017_}
C {devices/lab_pin.sym} 3170 2850 0 0 {name=l606 lab=_018_}
C {devices/lab_pin.sym} 4720 2440 0 0 {name=l607 lab=_018_}
C {devices/lab_pin.sym} 3720 3230 0 0 {name=l608 lab=_019_}
C {devices/lab_pin.sym} 5820 1870 0 0 {name=l609 lab=_019_}
C {devices/lab_pin.sym} 3720 3420 0 0 {name=l610 lab=_020_}
C {devices/lab_pin.sym} 5820 2060 0 0 {name=l611 lab=_020_}
C {devices/lab_pin.sym} 3720 3040 0 0 {name=l612 lab=_021_}
C {devices/lab_pin.sym} 5820 1680 0 0 {name=l613 lab=_021_}
C {devices/lab_pin.sym} 3720 2470 0 0 {name=l614 lab=_022_}
C {devices/lab_pin.sym} 5820 1490 0 0 {name=l615 lab=_022_}
C {devices/lab_pin.sym} 3720 2280 0 0 {name=l616 lab=_023_}
C {devices/lab_pin.sym} 5820 1300 0 0 {name=l617 lab=_023_}
C {devices/lab_pin.sym} 3720 1900 0 0 {name=l618 lab=_024_}
C {devices/lab_pin.sym} 5820 1110 0 0 {name=l619 lab=_024_}
C {devices/lab_pin.sym} 3720 1520 0 0 {name=l620 lab=_025_}
C {devices/lab_pin.sym} 5820 920 0 0 {name=l621 lab=_025_}
C {devices/lab_pin.sym} 5410 190 0 0 {name=l622 lab=_026_}
C {devices/lab_pin.sym} 5820 160 0 0 {name=l623 lab=_026_}
C {devices/lab_pin.sym} 3210 570 0 0 {name=l624 lab=_027_}
C {devices/lab_pin.sym} 4720 540 0 0 {name=l625 lab=_027_}
C {devices/lab_pin.sym} 5410 380 0 0 {name=l626 lab=_028_}
C {devices/lab_pin.sym} 5820 350 0 0 {name=l627 lab=_028_}
C {devices/lab_pin.sym} 3170 1710 0 0 {name=l628 lab=_029_}
C {devices/lab_pin.sym} 4720 1680 0 0 {name=l629 lab=_029_}
C {devices/lab_pin.sym} 3720 3610 0 0 {name=l630 lab=_030_}
C {devices/lab_pin.sym} 5820 2250 0 0 {name=l631 lab=_030_}
C {devices/lab_pin.sym} 3170 3800 0 0 {name=l632 lab=_031_}
C {devices/lab_pin.sym} 4720 3960 0 0 {name=l633 lab=_031_}
C {devices/lab_pin.sym} 5370 570 0 0 {name=l634 lab=_032_}
C {devices/lab_pin.sym} 5820 540 0 0 {name=l635 lab=_032_}
C {devices/lab_pin.sym} 3170 3230 0 0 {name=l636 lab=_033_}
C {devices/lab_pin.sym} 4720 2630 0 0 {name=l637 lab=_033_}
C {devices/lab_pin.sym} 1550 1330 0 0 {name=l638 lab=_034_}
C {devices/lab_pin.sym} 1980 550 0 0 {name=l639 lab=_034_}
C {devices/lab_pin.sym} 1980 2640 0 0 {name=l640 lab=_034_}
C {devices/lab_pin.sym} 1550 570 0 0 {name=l641 lab=_035_}
C {devices/lab_pin.sym} 1980 0 0 0 {name=l642 lab=_035_}
C {devices/lab_pin.sym} 1980 2470 0 0 {name=l643 lab=_035_}
C {devices/lab_pin.sym} 1550 190 0 0 {name=l644 lab=_036_}
C {devices/lab_pin.sym} 4730 930 0 0 {name=l645 lab=_036_}
C {devices/lab_pin.sym} 3630 -20 0 0 {name=l646 lab=_036_}
C {devices/lab_pin.sym} 3080 360 0 0 {name=l647 lab=_036_}
C {devices/lab_pin.sym} 1550 0 0 0 {name=l648 lab=_037_}
C {devices/lab_pin.sym} 3630 190 0 0 {name=l649 lab=_037_}
C {devices/lab_pin.sym} 1550 380 0 0 {name=l650 lab=_038_}
C {devices/lab_pin.sym} 1980 780 0 0 {name=l651 lab=_038_}
C {devices/lab_pin.sym} 1550 950 0 0 {name=l652 lab=_039_}
C {devices/lab_pin.sym} 1980 1350 0 0 {name=l653 lab=_039_}
C {devices/lab_pin.sym} 1550 1900 0 0 {name=l654 lab=_040_}
C {devices/lab_pin.sym} 4180 1880 0 0 {name=l655 lab=_040_}
C {devices/lab_pin.sym} 3200 2090 0 0 {name=l656 lab=_041_}
C {devices/lab_pin.sym} 3630 2110 0 0 {name=l657 lab=_041_}
C {devices/lab_pin.sym} 3230 3040 0 0 {name=l658 lab=_042_}
C {devices/lab_pin.sym} 3630 2680 0 0 {name=l659 lab=_042_}
C {devices/lab_pin.sym} 1560 2090 0 0 {name=l660 lab=_043_}
C {devices/lab_pin.sym} 1980 1160 0 0 {name=l661 lab=_043_}
C {devices/lab_pin.sym} 1980 3820 0 0 {name=l662 lab=_043_}
C {devices/lab_pin.sym} 1560 760 0 0 {name=l663 lab=_044_}
C {devices/lab_pin.sym} 1980 970 0 0 {name=l664 lab=_044_}
C {devices/lab_pin.sym} 4180 930 0 0 {name=l665 lab=_044_}
C {devices/lab_pin.sym} 4180 1120 0 0 {name=l666 lab=_044_}
C {devices/lab_pin.sym} 1980 400 0 0 {name=l667 lab=_044_}
C {devices/lab_pin.sym} 1980 2870 0 0 {name=l668 lab=_044_}
C {devices/lab_pin.sym} 2130 950 0 0 {name=l669 lab=_045_}
C {devices/lab_pin.sym} 4180 740 0 0 {name=l670 lab=_045_}
C {devices/lab_pin.sym} 4180 550 0 0 {name=l671 lab=_045_}
C {devices/lab_pin.sym} 1560 2280 0 0 {name=l672 lab=_046_}
C {devices/lab_pin.sym} 1980 2110 0 0 {name=l673 lab=_046_}
C {devices/lab_pin.sym} 1980 3630 0 0 {name=l674 lab=_046_}
C {devices/lab_pin.sym} 2110 2090 0 0 {name=l675 lab=_047_}
C {devices/lab_pin.sym} 2530 1710 0 0 {name=l676 lab=_047_}
C {devices/lab_pin.sym} 2530 1120 0 0 {name=l677 lab=_047_}
C {devices/lab_pin.sym} 2530 1500 0 0 {name=l678 lab=_047_}
C {devices/lab_pin.sym} 4740 350 0 0 {name=l679 lab=_047_}
C {devices/lab_pin.sym} 4730 -20 0 0 {name=l680 lab=_047_}
C {devices/lab_pin.sym} 2650 1710 0 0 {name=l681 lab=_048_}
C {devices/lab_pin.sym} 3630 1120 0 0 {name=l682 lab=_048_}
C {devices/lab_pin.sym} 3630 1310 0 0 {name=l683 lab=_048_}
C {devices/lab_pin.sym} 3080 2640 0 0 {name=l684 lab=_048_}
C {devices/lab_pin.sym} 2110 3610 0 0 {name=l685 lab=_049_}
C {devices/lab_pin.sym} 2530 1140 0 0 {name=l686 lab=_049_}
C {devices/lab_pin.sym} 2530 1520 0 0 {name=l687 lab=_049_}
C {devices/lab_pin.sym} 2530 1880 0 0 {name=l688 lab=_049_}
C {devices/lab_pin.sym} 2110 3800 0 0 {name=l689 lab=_050_}
C {devices/lab_pin.sym} 2530 1160 0 0 {name=l690 lab=_050_}
C {devices/lab_pin.sym} 2530 1540 0 0 {name=l691 lab=_050_}
C {devices/lab_pin.sym} 2530 2260 0 0 {name=l692 lab=_050_}
C {devices/lab_pin.sym} 2660 1140 0 0 {name=l693 lab=_051_}
C {devices/lab_pin.sym} 3080 740 0 0 {name=l694 lab=_051_}
C {devices/lab_pin.sym} 2660 1520 0 0 {name=l695 lab=_052_}
C {devices/lab_pin.sym} 3090 1890 0 0 {name=l696 lab=_052_}
C {devices/lab_pin.sym} 3080 1540 0 0 {name=l697 lab=_052_}
C {devices/lab_pin.sym} 3080 550 0 0 {name=l698 lab=_052_}
C {devices/lab_pin.sym} 1560 1140 0 0 {name=l699 lab=_053_}
C {devices/lab_pin.sym} 3080 780 0 0 {name=l700 lab=_053_}
C {devices/lab_pin.sym} 2530 2300 0 0 {name=l701 lab=_053_}
C {devices/lab_pin.sym} 3080 590 0 0 {name=l702 lab=_053_}
C {devices/lab_pin.sym} 2530 1920 0 0 {name=l703 lab=_053_}
C {devices/lab_pin.sym} 3210 760 0 0 {name=l704 lab=_054_}
C {devices/lab_pin.sym} 3630 1160 0 0 {name=l705 lab=_054_}
C {devices/lab_pin.sym} 3630 1350 0 0 {name=l706 lab=_054_}
C {devices/lab_pin.sym} 4180 360 0 0 {name=l707 lab=_054_}
C {devices/lab_pin.sym} 3630 400 0 0 {name=l708 lab=_054_}
C {devices/lab_pin.sym} 3630 780 0 0 {name=l709 lab=_054_}
C {devices/lab_pin.sym} 3760 1140 0 0 {name=l710 lab=_055_}
C {devices/lab_pin.sym} 4180 1140 0 0 {name=l711 lab=_055_}
C {devices/lab_pin.sym} 4180 590 0 0 {name=l712 lab=_055_}
C {devices/lab_pin.sym} 3780 1330 0 0 {name=l713 lab=_056_}
C {devices/lab_pin.sym} 4180 780 0 0 {name=l714 lab=_056_}
C {devices/lab_pin.sym} 4180 970 0 0 {name=l715 lab=_056_}
C {devices/lab_pin.sym} 4330 760 0 0 {name=l716 lab=_057_}
C {devices/lab_pin.sym} 4730 740 0 0 {name=l717 lab=_057_}
C {devices/lab_pin.sym} 1560 1710 0 0 {name=l718 lab=_058_}
C {devices/lab_pin.sym} 1980 1920 0 0 {name=l719 lab=_058_}
C {devices/lab_pin.sym} 1980 1730 0 0 {name=l720 lab=_058_}
C {devices/lab_pin.sym} 2110 1900 0 0 {name=l721 lab=_059_}
C {devices/lab_pin.sym} 3090 1910 0 0 {name=l722 lab=_059_}
C {devices/lab_pin.sym} 2530 400 0 0 {name=l723 lab=_059_}
C {devices/lab_pin.sym} 4740 370 0 0 {name=l724 lab=_059_}
C {devices/lab_pin.sym} 2110 1710 0 0 {name=l725 lab=_060_}
C {devices/lab_pin.sym} 3090 1930 0 0 {name=l726 lab=_060_}
C {devices/lab_pin.sym} 2530 170 0 0 {name=l727 lab=_060_}
C {devices/lab_pin.sym} 2530 740 0 0 {name=l728 lab=_060_}
C {devices/lab_pin.sym} 2530 590 0 0 {name=l729 lab=_060_}
C {devices/lab_pin.sym} 3210 1900 0 0 {name=l730 lab=_061_}
C {devices/lab_pin.sym} 3630 950 0 0 {name=l731 lab=_061_}
C {devices/lab_pin.sym} 3630 1730 0 0 {name=l732 lab=_061_}
C {devices/lab_pin.sym} 3630 2870 0 0 {name=l733 lab=_061_}
C {devices/lab_pin.sym} 3750 950 0 0 {name=l734 lab=_062_}
C {devices/lab_pin.sym} 4730 780 0 0 {name=l735 lab=_062_}
C {devices/lab_pin.sym} 4180 400 0 0 {name=l736 lab=_062_}
C {devices/lab_pin.sym} 4880 760 0 0 {name=l737 lab=_063_}
C {devices/lab_pin.sym} 5280 740 0 0 {name=l738 lab=_063_}
C {devices/lab_pin.sym} 5280 590 0 0 {name=l739 lab=_063_}
C {devices/lab_pin.sym} 4330 950 0 0 {name=l740 lab=_064_}
C {devices/lab_pin.sym} 4730 970 0 0 {name=l741 lab=_064_}
C {devices/lab_pin.sym} 4880 950 0 0 {name=l742 lab=_065_}
C {devices/lab_pin.sym} 5280 780 0 0 {name=l743 lab=_065_}
C {devices/lab_pin.sym} 3780 1710 0 0 {name=l744 lab=_066_}
C {devices/lab_pin.sym} 4730 1120 0 0 {name=l745 lab=_066_}
C {devices/lab_pin.sym} 1560 1520 0 0 {name=l746 lab=_067_}
C {devices/lab_pin.sym} 4180 1160 0 0 {name=l747 lab=_067_}
C {devices/lab_pin.sym} 1980 3400 0 0 {name=l748 lab=_067_}
C {devices/lab_pin.sym} 1980 210 0 0 {name=l749 lab=_067_}
C {devices/lab_pin.sym} 1980 2300 0 0 {name=l750 lab=_067_}
C {devices/lab_pin.sym} 4310 1140 0 0 {name=l751 lab=_068_}
C {devices/lab_pin.sym} 4730 1160 0 0 {name=l752 lab=_068_}
C {devices/lab_pin.sym} 3780 2850 0 0 {name=l753 lab=_069_}
C {devices/lab_pin.sym} 4180 1690 0 0 {name=l754 lab=_069_}
C {devices/lab_pin.sym} 3230 1520 0 0 {name=l755 lab=_070_}
C {devices/lab_pin.sym} 4180 1730 0 0 {name=l756 lab=_070_}
C {devices/lab_pin.sym} 2680 2280 0 0 {name=l757 lab=_071_}
C {devices/lab_pin.sym} 3120 4030 0 0 {name=l758 lab=_071_}
C {devices/lab_pin.sym} 3120 3650 0 0 {name=l759 lab=_071_}
C {devices/lab_pin.sym} 3120 3460 0 0 {name=l760 lab=_071_}
C {devices/lab_pin.sym} 3120 2510 0 0 {name=l761 lab=_071_}
C {devices/lab_pin.sym} 3120 2320 0 0 {name=l762 lab=_071_}
C {devices/lab_pin.sym} 3120 1370 0 0 {name=l763 lab=_071_}
C {devices/lab_pin.sym} 3120 2890 0 0 {name=l764 lab=_071_}
C {devices/lab_pin.sym} 3080 170 0 0 {name=l765 lab=_071_}
C {devices/lab_pin.sym} 3120 3840 0 0 {name=l766 lab=_071_}
C {devices/lab_pin.sym} 1560 2660 0 0 {name=l767 lab=_072_}
C {devices/lab_pin.sym} 1980 3440 0 0 {name=l768 lab=_072_}
C {devices/lab_pin.sym} 2130 3420 0 0 {name=l769 lab=_073_}
C {devices/lab_pin.sym} 3080 2680 0 0 {name=l770 lab=_073_}
C {devices/lab_pin.sym} 4730 0 0 0 {name=l771 lab=_073_}
C {devices/lab_pin.sym} 3210 2660 0 0 {name=l772 lab=_074_}
C {devices/lab_pin.sym} 3670 3270 0 0 {name=l773 lab=_074_}
C {devices/lab_pin.sym} 3670 3460 0 0 {name=l774 lab=_074_}
C {devices/lab_pin.sym} 3670 3080 0 0 {name=l775 lab=_074_}
C {devices/lab_pin.sym} 3670 2510 0 0 {name=l776 lab=_074_}
C {devices/lab_pin.sym} 3670 2320 0 0 {name=l777 lab=_074_}
C {devices/lab_pin.sym} 3670 1940 0 0 {name=l778 lab=_074_}
C {devices/lab_pin.sym} 3670 1560 0 0 {name=l779 lab=_074_}
C {devices/lab_pin.sym} 3630 590 0 0 {name=l780 lab=_074_}
C {devices/lab_pin.sym} 3670 3650 0 0 {name=l781 lab=_074_}
C {devices/lab_pin.sym} 2130 760 0 0 {name=l782 lab=_075_}
C {devices/lab_pin.sym} 2530 210 0 0 {name=l783 lab=_075_}
C {devices/lab_pin.sym} 2660 190 0 0 {name=l784 lab=_076_}
C {devices/lab_pin.sym} 4740 180 0 0 {name=l785 lab=_076_}
C {devices/lab_pin.sym} 2680 380 0 0 {name=l786 lab=_077_}
C {devices/lab_pin.sym} 3080 210 0 0 {name=l787 lab=_077_}
C {devices/lab_pin.sym} 3230 190 0 0 {name=l788 lab=_078_}
C {devices/lab_pin.sym} 4740 200 0 0 {name=l789 lab=_078_}
C {devices/lab_pin.sym} 4330 380 0 0 {name=l790 lab=_079_}
C {devices/lab_pin.sym} 4740 220 0 0 {name=l791 lab=_079_}
C {devices/lab_pin.sym} 4740 390 0 0 {name=l792 lab=_079_}
C {devices/lab_pin.sym} 4860 190 0 0 {name=l793 lab=_080_}
C {devices/lab_pin.sym} 5280 170 0 0 {name=l794 lab=_080_}
C {devices/lab_pin.sym} 3760 380 0 0 {name=l795 lab=_081_}
C {devices/lab_pin.sym} 5280 210 0 0 {name=l796 lab=_081_}
C {devices/lab_pin.sym} 3760 760 0 0 {name=l797 lab=_082_}
C {devices/lab_pin.sym} 5280 360 0 0 {name=l798 lab=_082_}
C {devices/lab_pin.sym} 2130 1330 0 0 {name=l799 lab=_083_}
C {devices/lab_pin.sym} 2530 780 0 0 {name=l800 lab=_083_}
C {devices/lab_pin.sym} 2660 760 0 0 {name=l801 lab=_084_}
C {devices/lab_pin.sym} 4740 410 0 0 {name=l802 lab=_084_}
C {devices/lab_pin.sym} 4860 380 0 0 {name=l803 lab=_085_}
C {devices/lab_pin.sym} 5280 400 0 0 {name=l804 lab=_085_}
C {devices/lab_pin.sym} 2680 1900 0 0 {name=l805 lab=_086_}
C {devices/lab_pin.sym} 3120 1750 0 0 {name=l806 lab=_086_}
C {devices/lab_pin.sym} 3120 3270 0 0 {name=l807 lab=_086_}
C {devices/lab_pin.sym} 3760 570 0 0 {name=l808 lab=_087_}
C {devices/lab_pin.sym} 4180 190 0 0 {name=l809 lab=_087_}
C {devices/lab_pin.sym} 2130 0 0 0 {name=l810 lab=_088_}
C {devices/lab_pin.sym} 2530 -30 0 0 {name=l811 lab=_088_}
C {devices/lab_pin.sym} 2130 190 0 0 {name=l812 lab=_089_}
C {devices/lab_pin.sym} 2530 -10 0 0 {name=l813 lab=_089_}
C {devices/lab_pin.sym} 2130 380 0 0 {name=l814 lab=_090_}
C {devices/lab_pin.sym} 2530 30 0 0 {name=l815 lab=_090_}
C {devices/lab_pin.sym} 2130 570 0 0 {name=l816 lab=_091_}
C {devices/lab_pin.sym} 2530 10 0 0 {name=l817 lab=_091_}
C {devices/lab_pin.sym} 2680 0 0 0 {name=l818 lab=_092_}
C {devices/lab_pin.sym} 3080 20 0 0 {name=l819 lab=_092_}
C {devices/lab_pin.sym} 3230 0 0 0 {name=l820 lab=_093_}
C {devices/lab_pin.sym} 3630 20 0 0 {name=l821 lab=_093_}
C {devices/lab_pin.sym} 3780 0 0 0 {name=l822 lab=_094_}
C {devices/lab_pin.sym} 4180 -20 0 0 {name=l823 lab=_094_}
C {devices/lab_pin.sym} 2130 2280 0 0 {name=l824 lab=_095_}
C {devices/lab_pin.sym} 2530 920 0 0 {name=l825 lab=_095_}
C {devices/lab_pin.sym} 2130 2470 0 0 {name=l826 lab=_096_}
C {devices/lab_pin.sym} 2530 940 0 0 {name=l827 lab=_096_}
C {devices/lab_pin.sym} 2130 2660 0 0 {name=l828 lab=_097_}
C {devices/lab_pin.sym} 2530 980 0 0 {name=l829 lab=_097_}
C {devices/lab_pin.sym} 2130 2850 0 0 {name=l830 lab=_098_}
C {devices/lab_pin.sym} 2530 960 0 0 {name=l831 lab=_098_}
C {devices/lab_pin.sym} 2680 950 0 0 {name=l832 lab=_099_}
C {devices/lab_pin.sym} 3080 400 0 0 {name=l833 lab=_099_}
C {devices/lab_pin.sym} 3210 380 0 0 {name=l834 lab=_100_}
C {devices/lab_pin.sym} 3630 210 0 0 {name=l835 lab=_100_}
C {devices/lab_pin.sym} 3760 190 0 0 {name=l836 lab=_101_}
C {devices/lab_pin.sym} 4180 20 0 0 {name=l837 lab=_101_}
C {devices/lab_pin.sym} 4330 0 0 0 {name=l838 lab=_102_}
C {devices/lab_pin.sym} 4730 20 0 0 {name=l839 lab=_102_}
C {devices/lab_pin.sym} 4880 0 0 0 {name=l840 lab=_103_}
C {devices/lab_pin.sym} 5280 -20 0 0 {name=l841 lab=_103_}
C {devices/lab_pin.sym} 2660 570 0 0 {name=l842 lab=_104_}
C {devices/lab_pin.sym} 4180 210 0 0 {name=l843 lab=_104_}
C {devices/lab_pin.sym} 4310 190 0 0 {name=l844 lab=_105_}
C {devices/lab_pin.sym} 5280 20 0 0 {name=l845 lab=_105_}
C {devices/lab_pin.sym} 4310 570 0 0 {name=l846 lab=_106_}
C {devices/lab_pin.sym} 5280 550 0 0 {name=l847 lab=_106_}
C {devices/lab_pin.sym} 3780 2090 0 0 {name=l848 lab=_107_}
C {devices/lab_pin.sym} 4180 1350 0 0 {name=l849 lab=_107_}
C {devices/lab_pin.sym} 1560 3040 0 0 {name=l850 lab=_108_}
C {devices/lab_pin.sym} 1990 4400 0 0 {name=l851 lab=_108_}
C {devices/lab_pin.sym} 2110 4370 0 0 {name=l852 lab=_109_}
C {devices/lab_pin.sym} 3080 3210 0 0 {name=l853 lab=_109_}
C {devices/lab_pin.sym} 4780 3430 0 0 {name=l854 lab=_110_}
C {devices/lab_pin.sym} 4780 4000 0 0 {name=l855 lab=_111_}
C {devices/lab_pin.sym} 5880 2290 0 0 {name=l856 lab=_112_}
C {devices/lab_pin.sym} 4780 4760 0 0 {name=l857 lab=_113_}
C {devices/lab_pin.sym} 4780 4380 0 0 {name=l858 lab=_114_}
C {devices/lab_pin.sym} 4780 4570 0 0 {name=l859 lab=_115_}
C {devices/lab_pin.sym} 4780 3810 0 0 {name=l860 lab=_116_}
C {devices/lab_pin.sym} 4780 3240 0 0 {name=l861 lab=_117_}
C {devices/lab_pin.sym} 4780 2290 0 0 {name=l862 lab=_118_}
C {devices/lab_pin.sym} 4780 2100 0 0 {name=l863 lab=_119_}
C {devices/lab_pin.sym} 4780 1530 0 0 {name=l864 lab=_120_}
C {devices/lab_pin.sym} 4780 2480 0 0 {name=l865 lab=_121_}
C {devices/lab_pin.sym} 5880 1910 0 0 {name=l866 lab=_122_}
C {devices/lab_pin.sym} 5880 2100 0 0 {name=l867 lab=_123_}
C {devices/lab_pin.sym} 5880 1720 0 0 {name=l868 lab=_124_}
C {devices/lab_pin.sym} 5880 1530 0 0 {name=l869 lab=_125_}
C {devices/lab_pin.sym} 5880 1340 0 0 {name=l870 lab=_126_}
C {devices/lab_pin.sym} 5880 1150 0 0 {name=l871 lab=_127_}
C {devices/lab_pin.sym} 5880 960 0 0 {name=l872 lab=_128_}
C {devices/lab_pin.sym} 4780 2860 0 0 {name=l873 lab=_129_}
C {devices/lab_pin.sym} 5880 10 0 0 {name=l874 lab=_130_}
C {devices/lab_pin.sym} 4780 3050 0 0 {name=l875 lab=_131_}
C {devices/lab_pin.sym} 4780 2670 0 0 {name=l876 lab=_132_}
C {devices/lab_pin.sym} 4780 1910 0 0 {name=l877 lab=_133_[0]}
C {devices/lab_pin.sym} 1440 1130 0 0 {name=l878 lab=_133_[0]}
C {devices/lab_pin.sym} 3080 1500 0 0 {name=l879 lab=_133_[0]}
C {devices/lab_pin.sym} 5330 1150 0 0 {name=l880 lab=_133_[1]}
C {devices/lab_pin.sym} 1440 1170 0 0 {name=l881 lab=_133_[1]}
C {devices/lab_pin.sym} 5880 770 0 0 {name=l882 lab=_133_[2]}
C {devices/lab_pin.sym} 1440 1150 0 0 {name=l883 lab=_133_[2]}
C {devices/lab_pin.sym} 3080 -20 0 0 {name=l884 lab=_133_[2]}
C {devices/lab_pin.sym} 5880 580 0 0 {name=l885 lab=_134_[3]}
C {devices/lab_pin.sym} 1430 0 0 0 {name=l886 lab=_134_[3]}
C {devices/lab_pin.sym} 4780 2630 0 0 {name=l887 lab=addr_match}
C {devices/lab_pin.sym} 1980 740 0 0 {name=l888 lab=addr_match}
C {devices/lab_pin.sym} 1980 1310 0 0 {name=l889 lab=addr_match}
C {devices/lab_pin.sym} 2530 550 0 0 {name=l890 lab=addr_match}
C {devices/lab_pin.sym} 3080 3250 0 0 {name=l891 lab=addr_match}
C {devices/lab_pin.sym} 4780 1870 0 0 {name=l892 lab=bit_cnt[0]}
C {devices/lab_pin.sym} 1430 1330 0 0 {name=l893 lab=bit_cnt[0]}
C {devices/lab_pin.sym} 1430 740 0 0 {name=l894 lab=bit_cnt[0]}
C {devices/lab_pin.sym} 1430 1500 0 0 {name=l895 lab=bit_cnt[0]}
C {devices/lab_pin.sym} 3630 2830 0 0 {name=l896 lab=bit_cnt[0]}
C {devices/lab_pin.sym} 1980 -20 0 0 {name=l897 lab=bit_cnt[0]}
C {devices/lab_pin.sym} 1980 2450 0 0 {name=l898 lab=bit_cnt[0]}
C {devices/lab_pin.sym} 5330 1110 0 0 {name=l899 lab=bit_cnt[1]}
C {devices/lab_pin.sym} 1430 570 0 0 {name=l900 lab=bit_cnt[1]}
C {devices/lab_pin.sym} 1430 780 0 0 {name=l901 lab=bit_cnt[1]}
C {devices/lab_pin.sym} 3630 1690 0 0 {name=l902 lab=bit_cnt[1]}
C {devices/lab_pin.sym} 1430 1540 0 0 {name=l903 lab=bit_cnt[1]}
C {devices/lab_pin.sym} 1980 570 0 0 {name=l904 lab=bit_cnt[1]}
C {devices/lab_pin.sym} 1980 2660 0 0 {name=l905 lab=bit_cnt[1]}
C {devices/lab_pin.sym} 5880 730 0 0 {name=l906 lab=bit_cnt[2]}
C {devices/lab_pin.sym} 1430 190 0 0 {name=l907 lab=bit_cnt[2]}
C {devices/lab_pin.sym} 1980 930 0 0 {name=l908 lab=bit_cnt[2]}
C {devices/lab_pin.sym} 1430 2680 0 0 {name=l909 lab=bit_cnt[2]}
C {devices/lab_pin.sym} 5880 540 0 0 {name=l910 lab=bit_cnt[3]}
C {devices/lab_pin.sym} 1440 1110 0 0 {name=l911 lab=bit_cnt[3]}
C {devices/lab_pin.sym} 1430 2640 0 0 {name=l912 lab=bit_cnt[3]}
C {devices/lab_pin.sym} 3630 170 0 0 {name=l913 lab=bit_cnt[3]}
C {devices/lab_pin.sym} 5320 610 0 0 {name=l914 lab=bit_cnt[3]}
C {devices/lab_pin.sym} 4860 1330 0 0 {name=l915 lab=busy}
C {devices/lab_pin.sym} 5280 930 0 0 {name=l916 lab=busy}
C {devices/lab_pin.sym} 4180 1540 0 0 {name=l917 lab=busy}
C {devices/lab_pin.sym} 4330 1330 0 0 {name=l918 lab=busy_clr}
C {devices/lab_pin.sym} 4730 1310 0 0 {name=l919 lab=busy_clr}
C {devices/lab_pin.sym} 4780 540 0 0 {name=l920 lab=phase[0]}
C {devices/lab_pin.sym} 1430 2300 0 0 {name=l921 lab=phase[0]}
C {devices/lab_pin.sym} 1980 3780 0 0 {name=l922 lab=phase[0]}
C {devices/lab_pin.sym} 5880 160 0 0 {name=l923 lab=phase[1]}
C {devices/lab_pin.sym} 1430 2260 0 0 {name=l924 lab=phase[1]}
C {devices/lab_pin.sym} 1430 1730 0 0 {name=l925 lab=phase[1]}
C {devices/lab_pin.sym} 3630 360 0 0 {name=l926 lab=phase[1]}
C {devices/lab_pin.sym} 5880 350 0 0 {name=l927 lab=phase[2]}
C {devices/lab_pin.sym} 1430 2070 0 0 {name=l928 lab=phase[2]}
C {devices/lab_pin.sym} 1980 3590 0 0 {name=l929 lab=phase[2]}
C {devices/lab_pin.sym} 1980 1690 0 0 {name=l930 lab=phase[2]}
C {devices/lab_pin.sym} 3630 740 0 0 {name=l931 lab=phase[2]}
C {devices/lab_pin.sym} 4310 1520 0 0 {name=l932 lab=qn}
C {devices/lab_pin.sym} 4730 1350 0 0 {name=l933 lab=qn}
C {devices/lab_pin.sym} 1430 1900 0 0 {name=l934 lab=rst_n}
C {devices/lab_pin.sym} 5280 970 0 0 {name=l935 lab=rst_n}
C {devices/lab_pin.sym} 4180 1310 0 0 {name=l936 lab=rst_n}
C {devices/lab_pin.sym} 4780 1680 0 0 {name=l937 lab=rw}
C {devices/lab_pin.sym} 1430 950 0 0 {name=l938 lab=rw}
C {devices/lab_pin.sym} 3080 1730 0 0 {name=l939 lab=rw}
C {devices/lab_pin.sym} 4780 2440 0 0 {name=l940 lab=rx_data[0]}
C {devices/lab_pin.sym} 3080 2870 0 0 {name=l941 lab=rx_data[0]}
C {devices/lab_pin.sym} 4780 1490 0 0 {name=l942 lab=rx_data[1]}
C {devices/lab_pin.sym} 3080 1350 0 0 {name=l943 lab=rx_data[1]}
C {devices/lab_pin.sym} 4780 2060 0 0 {name=l944 lab=rx_data[2]}
C {devices/lab_pin.sym} 3080 2300 0 0 {name=l945 lab=rx_data[2]}
C {devices/lab_pin.sym} 4780 2250 0 0 {name=l946 lab=rx_data[3]}
C {devices/lab_pin.sym} 3080 2490 0 0 {name=l947 lab=rx_data[3]}
C {devices/lab_pin.sym} 4780 3200 0 0 {name=l948 lab=rx_data[4]}
C {devices/lab_pin.sym} 3080 3440 0 0 {name=l949 lab=rx_data[4]}
C {devices/lab_pin.sym} 4780 3770 0 0 {name=l950 lab=rx_data[5]}
C {devices/lab_pin.sym} 3080 3630 0 0 {name=l951 lab=rx_data[5]}
C {devices/lab_pin.sym} 4780 4530 0 0 {name=l952 lab=rx_data[6]}
C {devices/lab_pin.sym} 3080 4010 0 0 {name=l953 lab=rx_data[6]}
C {devices/lab_pin.sym} 4780 3960 0 0 {name=l954 lab=rx_data[7]}
C {devices/lab_pin.sym} 3080 3820 0 0 {name=l955 lab=rx_data[7]}
C {devices/lab_pin.sym} 2110 1140 0 0 {name=l956 lab=rx_valid}
C {devices/lab_pin.sym} 3090 1870 0 0 {name=l957 lab=rx_valid}
C {devices/lab_pin.sym} 4740 160 0 0 {name=l958 lab=rx_valid}
C {devices/lab_pin.sym} 4180 170 0 0 {name=l959 lab=rx_valid}
C {devices/lab_pin.sym} 1430 2470 0 0 {name=l960 lab=scl}
C {devices/lab_pin.sym} 1550 2470 0 0 {name=l961 lab=scl_buf}
C {devices/lab_pin.sym} 1980 3040 0 0 {name=l962 lab=scl_buf}
C {devices/lab_pin.sym} 1980 1520 0 0 {name=l963 lab=scl_buf}
C {devices/lab_pin.sym} 1980 4180 0 0 {name=l964 lab=scl_buf}
C {devices/lab_pin.sym} 1980 4560 0 0 {name=l965 lab=scl_buf}
C {devices/lab_pin.sym} 2650 1330 0 0 {name=l966 lab=scl_n}
C {devices/lab_pin.sym} 3080 950 0 0 {name=l967 lab=scl_n}
C {devices/lab_pin.sym} 3080 1140 0 0 {name=l968 lab=scl_n}
C {devices/lab_pin.sym} 3200 950 0 0 {name=l969 lab=scl_n_row1}
C {devices/lab_pin.sym} 5820 1910 0 0 {name=l970 lab=scl_n_row1}
C {devices/lab_pin.sym} 5820 2290 0 0 {name=l971 lab=scl_n_row1}
C {devices/lab_pin.sym} 5820 10 0 0 {name=l972 lab=scl_n_row1}
C {devices/lab_pin.sym} 3200 1140 0 0 {name=l973 lab=scl_n_row2}
C {devices/lab_pin.sym} 5820 960 0 0 {name=l974 lab=scl_n_row2}
C {devices/lab_pin.sym} 5820 1150 0 0 {name=l975 lab=scl_n_row2}
C {devices/lab_pin.sym} 5820 1340 0 0 {name=l976 lab=scl_n_row2}
C {devices/lab_pin.sym} 5820 1530 0 0 {name=l977 lab=scl_n_row2}
C {devices/lab_pin.sym} 5820 1720 0 0 {name=l978 lab=scl_n_row2}
C {devices/lab_pin.sym} 5820 2100 0 0 {name=l979 lab=scl_n_row2}
C {devices/lab_pin.sym} 2100 3040 0 0 {name=l980 lab=scl_row0}
C {devices/lab_pin.sym} 4720 580 0 0 {name=l981 lab=scl_row0}
C {devices/lab_pin.sym} 5820 200 0 0 {name=l982 lab=scl_row0}
C {devices/lab_pin.sym} 5820 390 0 0 {name=l983 lab=scl_row0}
C {devices/lab_pin.sym} 4720 1720 0 0 {name=l984 lab=scl_row0}
C {devices/lab_pin.sym} 4720 1910 0 0 {name=l985 lab=scl_row0}
C {devices/lab_pin.sym} 2100 1520 0 0 {name=l986 lab=scl_row1}
C {devices/lab_pin.sym} 5270 1150 0 0 {name=l987 lab=scl_row1}
C {devices/lab_pin.sym} 5820 770 0 0 {name=l988 lab=scl_row1}
C {devices/lab_pin.sym} 5820 580 0 0 {name=l989 lab=scl_row1}
C {devices/lab_pin.sym} 2100 4180 0 0 {name=l990 lab=scl_row2}
C {devices/lab_pin.sym} 3080 3020 0 0 {name=l991 lab=scl_row2}
C {devices/lab_pin.sym} 3630 2090 0 0 {name=l992 lab=scl_row2}
C {devices/lab_pin.sym} 4720 3050 0 0 {name=l993 lab=scl_row2}
C {devices/lab_pin.sym} 4720 3430 0 0 {name=l994 lab=scl_row2}
C {devices/lab_pin.sym} 4720 2860 0 0 {name=l995 lab=scl_row2}
C {devices/lab_pin.sym} 4720 4760 0 0 {name=l996 lab=scl_row2}
C {devices/lab_pin.sym} 2530 1330 0 0 {name=l997 lab=scl_row2}
C {devices/lab_pin.sym} 2100 4560 0 0 {name=l998 lab=scl_row3}
C {devices/lab_pin.sym} 4720 2480 0 0 {name=l999 lab=scl_row3}
C {devices/lab_pin.sym} 4720 1530 0 0 {name=l1000 lab=scl_row3}
C {devices/lab_pin.sym} 4720 2100 0 0 {name=l1001 lab=scl_row3}
C {devices/lab_pin.sym} 4720 2290 0 0 {name=l1002 lab=scl_row3}
C {devices/lab_pin.sym} 4720 3240 0 0 {name=l1003 lab=scl_row3}
C {devices/lab_pin.sym} 4720 3810 0 0 {name=l1004 lab=scl_row3}
C {devices/lab_pin.sym} 4720 4570 0 0 {name=l1005 lab=scl_row3}
C {devices/lab_pin.sym} 4720 4000 0 0 {name=l1006 lab=scl_row3}
C {devices/lab_pin.sym} 4720 2670 0 0 {name=l1007 lab=scl_row3}
C {devices/lab_pin.sym} 4720 4190 0 0 {name=l1008 lab=scl_row3}
C {devices/lab_pin.sym} 4720 4380 0 0 {name=l1009 lab=scl_row3}
C {devices/lab_pin.sym} 4720 3620 0 0 {name=l1010 lab=scl_row3}
C {devices/lab_pin.sym} 2650 2090 0 0 {name=l1011 lab=sda_d}
C {devices/lab_pin.sym} 3080 2090 0 0 {name=l1012 lab=sda_d}
C {devices/lab_pin.sym} 3080 3060 0 0 {name=l1013 lab=sda_d}
C {devices/lab_pin.sym} 1430 2850 0 0 {name=l1014 lab=sda_in}
C {devices/lab_pin.sym} 1550 2850 0 0 {name=l1015 lab=sda_in_buf}
C {devices/lab_pin.sym} 1980 3230 0 0 {name=l1016 lab=sda_in_buf}
C {devices/lab_pin.sym} 1980 3990 0 0 {name=l1017 lab=sda_in_buf}
C {devices/lab_pin.sym} 2100 3230 0 0 {name=l1018 lab=sda_in_row0}
C {devices/lab_pin.sym} 2530 360 0 0 {name=l1019 lab=sda_in_row0}
C {devices/lab_pin.sym} 3080 1690 0 0 {name=l1020 lab=sda_in_row0}
C {devices/lab_pin.sym} 2100 3990 0 0 {name=l1021 lab=sda_in_row3}
C {devices/lab_pin.sym} 3630 2640 0 0 {name=l1022 lab=sda_in_row3}
C {devices/lab_pin.sym} 3080 2830 0 0 {name=l1023 lab=sda_in_row3}
C {devices/lab_pin.sym} 3630 2070 0 0 {name=l1024 lab=sda_in_row3}
C {devices/lab_pin.sym} 4720 3010 0 0 {name=l1025 lab=sda_in_row3}
C {devices/lab_pin.sym} 2530 2090 0 0 {name=l1026 lab=sda_in_row3}
C {devices/lab_pin.sym} 5880 -30 0 0 {name=l1027 lab=sda_oe}
C {devices/lab_pin.sym} 4780 3010 0 0 {name=l1028 lab=shreg[0]}
C {devices/lab_pin.sym} 3080 1310 0 0 {name=l1029 lab=shreg[0]}
C {devices/lab_pin.sym} 1990 4360 0 0 {name=l1030 lab=shreg[0]}
C {devices/lab_pin.sym} 4720 3390 0 0 {name=l1031 lab=shreg[0]}
C {devices/lab_pin.sym} 4780 3390 0 0 {name=l1032 lab=shreg[1]}
C {devices/lab_pin.sym} 3080 2260 0 0 {name=l1033 lab=shreg[1]}
C {devices/lab_pin.sym} 1990 4380 0 0 {name=l1034 lab=shreg[1]}
C {devices/lab_pin.sym} 4720 2820 0 0 {name=l1035 lab=shreg[1]}
C {devices/lab_pin.sym} 4780 2820 0 0 {name=l1036 lab=shreg[2]}
C {devices/lab_pin.sym} 3080 2450 0 0 {name=l1037 lab=shreg[2]}
C {devices/lab_pin.sym} 1440 3070 0 0 {name=l1038 lab=shreg[2]}
C {devices/lab_pin.sym} 4720 4720 0 0 {name=l1039 lab=shreg[2]}
C {devices/lab_pin.sym} 4780 4720 0 0 {name=l1040 lab=shreg[3]}
C {devices/lab_pin.sym} 3080 3400 0 0 {name=l1041 lab=shreg[3]}
C {devices/lab_pin.sym} 1990 4340 0 0 {name=l1042 lab=shreg[3]}
C {devices/lab_pin.sym} 4720 4150 0 0 {name=l1043 lab=shreg[3]}
C {devices/lab_pin.sym} 4780 4150 0 0 {name=l1044 lab=shreg[4]}
C {devices/lab_pin.sym} 3080 3590 0 0 {name=l1045 lab=shreg[4]}
C {devices/lab_pin.sym} 4720 4340 0 0 {name=l1046 lab=shreg[4]}
C {devices/lab_pin.sym} 4780 4340 0 0 {name=l1047 lab=shreg[5]}
C {devices/lab_pin.sym} 3080 3970 0 0 {name=l1048 lab=shreg[5]}
C {devices/lab_pin.sym} 1440 3050 0 0 {name=l1049 lab=shreg[5]}
C {devices/lab_pin.sym} 4720 3580 0 0 {name=l1050 lab=shreg[5]}
C {devices/lab_pin.sym} 4780 3580 0 0 {name=l1051 lab=shreg[6]}
C {devices/lab_pin.sym} 3080 3780 0 0 {name=l1052 lab=shreg[6]}
C {devices/lab_pin.sym} 3760 2660 0 0 {name=l1053 lab=start_pulse}
C {devices/lab_pin.sym} 4180 1920 0 0 {name=l1054 lab=start_pulse}
C {devices/lab_pin.sym} 4180 1500 0 0 {name=l1055 lab=start_pulse}
C {devices/lab_pin.sym} 3630 1500 0 0 {name=l1056 lab=tx_data[0]}
C {devices/lab_pin.sym} 3630 1880 0 0 {name=l1057 lab=tx_data[1]}
C {devices/lab_pin.sym} 3630 2260 0 0 {name=l1058 lab=tx_data[2]}
C {devices/lab_pin.sym} 3630 2450 0 0 {name=l1059 lab=tx_data[3]}
C {devices/lab_pin.sym} 3630 3020 0 0 {name=l1060 lab=tx_data[4]}
C {devices/lab_pin.sym} 3630 3400 0 0 {name=l1061 lab=tx_data[5]}
C {devices/lab_pin.sym} 3630 3210 0 0 {name=l1062 lab=tx_data[6]}
C {devices/lab_pin.sym} 3630 550 0 0 {name=l1063 lab=tx_data[7]}
C {devices/lab_pin.sym} 3630 3590 0 0 {name=l1064 lab=tx_data[7]}
C {devices/lab_pin.sym} 5880 920 0 0 {name=l1065 lab=txreg[0]}
C {devices/lab_pin.sym} 3630 1540 0 0 {name=l1066 lab=txreg[0]}
C {devices/lab_pin.sym} 1980 2830 0 0 {name=l1067 lab=txreg[0]}
C {devices/lab_pin.sym} 5880 1110 0 0 {name=l1068 lab=txreg[1]}
C {devices/lab_pin.sym} 3630 1920 0 0 {name=l1069 lab=txreg[1]}
C {devices/lab_pin.sym} 1980 2680 0 0 {name=l1070 lab=txreg[1]}
C {devices/lab_pin.sym} 5880 1300 0 0 {name=l1071 lab=txreg[2]}
C {devices/lab_pin.sym} 3630 2300 0 0 {name=l1072 lab=txreg[2]}
C {devices/lab_pin.sym} 1980 2490 0 0 {name=l1073 lab=txreg[2]}
C {devices/lab_pin.sym} 5880 1490 0 0 {name=l1074 lab=txreg[3]}
C {devices/lab_pin.sym} 3630 2490 0 0 {name=l1075 lab=txreg[3]}
C {devices/lab_pin.sym} 1980 2260 0 0 {name=l1076 lab=txreg[3]}
C {devices/lab_pin.sym} 5880 1680 0 0 {name=l1077 lab=txreg[4]}
C {devices/lab_pin.sym} 3630 3060 0 0 {name=l1078 lab=txreg[4]}
C {devices/lab_pin.sym} 1980 360 0 0 {name=l1079 lab=txreg[4]}
C {devices/lab_pin.sym} 5880 2060 0 0 {name=l1080 lab=txreg[5]}
C {devices/lab_pin.sym} 3630 3440 0 0 {name=l1081 lab=txreg[5]}
C {devices/lab_pin.sym} 1980 590 0 0 {name=l1082 lab=txreg[5]}
C {devices/lab_pin.sym} 5880 1870 0 0 {name=l1083 lab=txreg[6]}
C {devices/lab_pin.sym} 3630 3250 0 0 {name=l1084 lab=txreg[6]}
C {devices/lab_pin.sym} 1980 20 0 0 {name=l1085 lab=txreg[6]}
C {devices/lab_pin.sym} 5880 2250 0 0 {name=l1086 lab=txreg[7]}
C {devices/lab_pin.sym} 3630 3630 0 0 {name=l1087 lab=txreg[7]}
C {devices/lab_pin.sym} 1980 170 0 0 {name=l1088 lab=txreg[7]}
