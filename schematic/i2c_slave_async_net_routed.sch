v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 1330 0 0 {name=_336_}
N 1480 1290 1480 1275 {}
C {devices/lab_pin.sym} 1480 1275 0 0 {name=l1 lab=VDD}
N 1480 1370 1480 1385 {}
C {devices/lab_pin.sym} 1480 1385 0 0 {name=l2 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 570 0 0 {name=_337_}
N 1480 530 1480 515 {}
C {devices/lab_pin.sym} 1480 515 0 0 {name=l3 lab=VDD}
N 1480 610 1480 625 {}
C {devices/lab_pin.sym} 1480 625 0 0 {name=l4 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 190 0 0 {name=_338_}
N 1480 150 1480 135 {}
C {devices/lab_pin.sym} 1480 135 0 0 {name=l5 lab=VDD}
N 1480 230 1480 245 {}
C {devices/lab_pin.sym} 1480 245 0 0 {name=l6 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 760 0 0 {name=_339_}
N 1480 720 1480 705 {}
C {devices/lab_pin.sym} 1480 705 0 0 {name=l7 lab=VDD}
N 1480 800 1480 815 {}
C {devices/lab_pin.sym} 1480 815 0 0 {name=l8 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 2660 0 0 {name=_340_}
N 1480 2620 1480 2605 {}
C {devices/lab_pin.sym} 1480 2605 0 0 {name=l9 lab=VDD}
N 1480 2700 1480 2715 {}
C {devices/lab_pin.sym} 1480 2715 0 0 {name=l10 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 0 0 0 {name=_341_}
N 1480 -40 1480 -55 {}
C {devices/lab_pin.sym} 1480 -55 0 0 {name=l11 lab=VDD}
N 1480 40 1480 55 {}
C {devices/lab_pin.sym} 1480 55 0 0 {name=l12 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 2090 0 0 {name=_342_}
N 1480 2050 1480 2035 {}
C {devices/lab_pin.sym} 1480 2035 0 0 {name=l13 lab=VDD}
N 1480 2130 1480 2145 {}
C {devices/lab_pin.sym} 1480 2145 0 0 {name=l14 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2000 3420 0 0 {name=_343_}
N 2030 3380 2030 3365 {}
C {devices/lab_pin.sym} 2030 3365 0 0 {name=l15 lab=VDD}
N 2030 3460 2030 3475 {}
C {devices/lab_pin.sym} 2030 3475 0 0 {name=l16 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1450 2470 0 0 {name=_344_}
N 1480 2410 1480 2395 {}
C {devices/lab_pin.sym} 1480 2395 0 0 {name=l17 lab=VDD}
N 1480 2530 1480 2545 {}
C {devices/lab_pin.sym} 1480 2545 0 0 {name=l18 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 2280 0 0 {name=_345_}
N 2030 2220 2030 2205 {}
C {devices/lab_pin.sym} 2030 2205 0 0 {name=l19 lab=VDD}
N 2030 2340 2030 2355 {}
C {devices/lab_pin.sym} 2030 2355 0 0 {name=l20 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 3230 0 0 {name=_346_}
N 2030 3170 2030 3155 {}
C {devices/lab_pin.sym} 2030 3155 0 0 {name=l21 lab=VDD}
N 2030 3290 2030 3305 {}
C {devices/lab_pin.sym} 2030 3305 0 0 {name=l22 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1450 1900 0 0 {name=_347_}
N 1480 1840 1480 1825 {}
C {devices/lab_pin.sym} 1480 1825 0 0 {name=l23 lab=VDD}
N 1480 1960 1480 1975 {}
C {devices/lab_pin.sym} 1480 1975 0 0 {name=l24 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 2850 0 0 {name=_348_}
N 2030 2790 2030 2775 {}
C {devices/lab_pin.sym} 2030 2775 0 0 {name=l25 lab=VDD}
N 2030 2910 2030 2925 {}
C {devices/lab_pin.sym} 2030 2925 0 0 {name=l26 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 1330 0 0 {name=_349_}
N 2030 1270 2030 1255 {}
C {devices/lab_pin.sym} 2030 1255 0 0 {name=l27 lab=VDD}
N 2030 1390 2030 1405 {}
C {devices/lab_pin.sym} 2030 1405 0 0 {name=l28 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 2550 950 0 0 {name=_350_}
N 2580 910 2580 895 {}
C {devices/lab_pin.sym} 2580 895 0 0 {name=l29 lab=VDD}
N 2580 990 2580 1005 {}
C {devices/lab_pin.sym} 2580 1005 0 0 {name=l30 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 2550 0 0 0 {name=_351_}
N 2580 -60 2580 -75 {}
C {devices/lab_pin.sym} 2580 -75 0 0 {name=l31 lab=VDD}
N 2580 60 2580 75 {}
C {devices/lab_pin.sym} 2580 75 0 0 {name=l32 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR3.sym} 2550 1330 0 0 {name=_352_}
N 2580 1270 2580 1255 {}
C {devices/lab_pin.sym} 2580 1255 0 0 {name=l33 lab=VDD}
N 2580 1390 2580 1405 {}
C {devices/lab_pin.sym} 2580 1405 0 0 {name=l34 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 1450 950 0 0 {name=_353_}
N 1480 890 1480 875 {}
C {devices/lab_pin.sym} 1480 875 0 0 {name=l35 lab=VDD}
N 1480 1010 1480 1025 {}
C {devices/lab_pin.sym} 1480 1025 0 0 {name=l36 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 190 0 0 {name=_354_}
N 2030 130 2030 115 {}
C {devices/lab_pin.sym} 2030 115 0 0 {name=l37 lab=VDD}
N 2030 250 2030 265 {}
C {devices/lab_pin.sym} 2030 265 0 0 {name=l38 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2000 2470 0 0 {name=_355_}
N 2030 2410 2030 2395 {}
C {devices/lab_pin.sym} 2030 2395 0 0 {name=l39 lab=VDD}
N 2030 2530 2030 2545 {}
C {devices/lab_pin.sym} 2030 2545 0 0 {name=l40 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 3100 760 0 0 {name=_356_}
N 3130 700 3130 685 {}
C {devices/lab_pin.sym} 3130 685 0 0 {name=l41 lab=VDD}
N 3130 820 3130 835 {}
C {devices/lab_pin.sym} 3130 835 0 0 {name=l42 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 3650 380 0 0 {name=_357_}
N 3680 340 3680 325 {}
C {devices/lab_pin.sym} 3680 325 0 0 {name=l43 lab=VDD}
N 3680 420 3680 435 {}
C {devices/lab_pin.sym} 3680 435 0 0 {name=l44 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 1450 380 0 0 {name=_358_}
N 1480 320 1480 305 {}
C {devices/lab_pin.sym} 1480 305 0 0 {name=l45 lab=VDD}
N 1480 440 1480 455 {}
C {devices/lab_pin.sym} 1480 455 0 0 {name=l46 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 0 0 0 {name=_359_}
N 2030 -60 2030 -75 {}
C {devices/lab_pin.sym} 2030 -75 0 0 {name=l47 lab=VDD}
N 2030 60 2030 75 {}
C {devices/lab_pin.sym} 2030 75 0 0 {name=l48 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 1450 1140 0 0 {name=_360_}
N 1480 1080 1480 1065 {}
C {devices/lab_pin.sym} 1480 1065 0 0 {name=l49 lab=VDD}
N 1480 1200 1480 1215 {}
C {devices/lab_pin.sym} 1480 1215 0 0 {name=l50 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 3100 0 0 0 {name=_361_}
N 3130 -60 3130 -75 {}
C {devices/lab_pin.sym} 3130 -75 0 0 {name=l51 lab=VDD}
N 3130 60 3130 75 {}
C {devices/lab_pin.sym} 3130 75 0 0 {name=l52 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3650 570 0 0 {name=_362_}
N 3680 510 3680 495 {}
C {devices/lab_pin.sym} 3680 495 0 0 {name=l53 lab=VDD}
N 3680 630 3680 645 {}
C {devices/lab_pin.sym} 3680 645 0 0 {name=l54 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3650 0 0 0 {name=_363_}
N 3680 -60 3680 -75 {}
C {devices/lab_pin.sym} 3680 -75 0 0 {name=l55 lab=VDD}
N 3680 60 3680 75 {}
C {devices/lab_pin.sym} 3680 75 0 0 {name=l56 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 0 0 0 {name=_364_}
N 4230 -60 4230 -75 {}
C {devices/lab_pin.sym} 4230 -75 0 0 {name=l57 lab=VDD}
N 4230 60 4230 75 {}
C {devices/lab_pin.sym} 4230 75 0 0 {name=l58 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4750 0 0 0 {name=_365_}
N 4780 -60 4780 -75 {}
C {devices/lab_pin.sym} 4780 -75 0 0 {name=l59 lab=VDD}
N 4780 60 4780 75 {}
C {devices/lab_pin.sym} 4780 75 0 0 {name=l60 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 380 0 0 {name=_366_}
N 4230 320 4230 305 {}
C {devices/lab_pin.sym} 4230 305 0 0 {name=l61 lab=VDD}
N 4230 440 4230 455 {}
C {devices/lab_pin.sym} 4230 455 0 0 {name=l62 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4750 380 0 0 {name=_367_}
N 4780 320 4780 305 {}
C {devices/lab_pin.sym} 4780 305 0 0 {name=l63 lab=VDD}
N 4780 440 4780 455 {}
C {devices/lab_pin.sym} 4780 455 0 0 {name=l64 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 5300 380 0 0 {name=_368_}
N 5330 320 5330 305 {}
C {devices/lab_pin.sym} 5330 305 0 0 {name=l65 lab=VDD}
N 5330 440 5330 455 {}
C {devices/lab_pin.sym} 5330 455 0 0 {name=l66 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3650 1330 0 0 {name=_369_}
N 3680 1270 3680 1255 {}
C {devices/lab_pin.sym} 3680 1255 0 0 {name=l67 lab=VDD}
N 3680 1390 3680 1405 {}
C {devices/lab_pin.sym} 3680 1405 0 0 {name=l68 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1450 1520 0 0 {name=_370_}
N 1480 1460 1480 1445 {}
C {devices/lab_pin.sym} 1480 1445 0 0 {name=l69 lab=VDD}
N 1480 1580 1480 1595 {}
C {devices/lab_pin.sym} 1480 1595 0 0 {name=l70 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR3.sym} 4200 1140 0 0 {name=_371_}
N 4230 1080 4230 1065 {}
C {devices/lab_pin.sym} 4230 1065 0 0 {name=l71 lab=VDD}
N 4230 1200 4230 1215 {}
C {devices/lab_pin.sym} 4230 1215 0 0 {name=l72 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4750 950 0 0 {name=_372_}
N 4780 890 4780 875 {}
C {devices/lab_pin.sym} 4780 875 0 0 {name=l73 lab=VDD}
N 4780 1010 4780 1025 {}
C {devices/lab_pin.sym} 4780 1025 0 0 {name=l74 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3650 1900 0 0 {name=_373_}
N 3680 1840 3680 1825 {}
C {devices/lab_pin.sym} 3680 1825 0 0 {name=l75 lab=VDD}
N 3680 1960 3680 1975 {}
C {devices/lab_pin.sym} 3680 1975 0 0 {name=l76 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3100 950 0 0 {name=_374_}
N 3130 890 3130 875 {}
C {devices/lab_pin.sym} 3130 875 0 0 {name=l77 lab=VDD}
N 3130 1010 3130 1025 {}
C {devices/lab_pin.sym} 3130 1025 0 0 {name=l78 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 1330 0 0 {name=_375_}
N 4230 1270 4230 1255 {}
C {devices/lab_pin.sym} 4230 1255 0 0 {name=l79 lab=VDD}
N 4230 1390 4230 1405 {}
C {devices/lab_pin.sym} 4230 1405 0 0 {name=l80 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2550 2280 0 0 {name=_376_}
N 2580 2220 2580 2205 {}
C {devices/lab_pin.sym} 2580 2205 0 0 {name=l81 lab=VDD}
N 2580 2340 2580 2355 {}
C {devices/lab_pin.sym} 2580 2355 0 0 {name=l82 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 3800 0 0 {name=_377_}
N 3140 3760 3155 3760 {}
C {devices/lab_pin.sym} 3155 3760 0 0 {name=l83 lab=VDD}
N 3140 3840 3155 3840 {}
C {devices/lab_pin.sym} 3155 3840 0 0 {name=l84 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 3420 0 0 {name=_378_}
N 3140 3380 3155 3380 {}
C {devices/lab_pin.sym} 3155 3380 0 0 {name=l85 lab=VDD}
N 3140 3460 3155 3460 {}
C {devices/lab_pin.sym} 3155 3460 0 0 {name=l86 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 3610 0 0 {name=_379_}
N 3140 3570 3155 3570 {}
C {devices/lab_pin.sym} 3155 3570 0 0 {name=l87 lab=VDD}
N 3140 3650 3155 3650 {}
C {devices/lab_pin.sym} 3155 3650 0 0 {name=l88 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 3040 0 0 {name=_380_}
N 3140 3000 3155 3000 {}
C {devices/lab_pin.sym} 3155 3000 0 0 {name=l89 lab=VDD}
N 3140 3080 3155 3080 {}
C {devices/lab_pin.sym} 3155 3080 0 0 {name=l90 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 2850 0 0 {name=_381_}
N 3140 2810 3155 2810 {}
C {devices/lab_pin.sym} 3155 2810 0 0 {name=l91 lab=VDD}
N 3140 2890 3155 2890 {}
C {devices/lab_pin.sym} 3155 2890 0 0 {name=l92 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 2470 0 0 {name=_382_}
N 3140 2430 3155 2430 {}
C {devices/lab_pin.sym} 3155 2430 0 0 {name=l93 lab=VDD}
N 3140 2510 3155 2510 {}
C {devices/lab_pin.sym} 3155 2510 0 0 {name=l94 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 1330 0 0 {name=_383_}
N 3140 1290 3155 1290 {}
C {devices/lab_pin.sym} 3155 1290 0 0 {name=l95 lab=VDD}
N 3140 1370 3155 1370 {}
C {devices/lab_pin.sym} 3155 1370 0 0 {name=l96 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 1450 2280 0 0 {name=_384_}
N 1480 2220 1480 2205 {}
C {devices/lab_pin.sym} 1480 2205 0 0 {name=l97 lab=VDD}
N 1480 2340 1480 2355 {}
C {devices/lab_pin.sym} 1480 2355 0 0 {name=l98 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 2660 0 0 {name=_385_}
N 2030 2600 2030 2585 {}
C {devices/lab_pin.sym} 2030 2585 0 0 {name=l99 lab=VDD}
N 2030 2720 2030 2735 {}
C {devices/lab_pin.sym} 2030 2735 0 0 {name=l100 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 3100 1520 0 0 {name=_386_}
N 3130 1460 3130 1445 {}
C {devices/lab_pin.sym} 3130 1445 0 0 {name=l101 lab=VDD}
N 3130 1580 3130 1595 {}
C {devices/lab_pin.sym} 3130 1595 0 0 {name=l102 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3650 3800 0 0 {name=_387_}
N 3690 3760 3705 3760 {}
C {devices/lab_pin.sym} 3705 3760 0 0 {name=l103 lab=VDD}
N 3690 3840 3705 3840 {}
C {devices/lab_pin.sym} 3705 3840 0 0 {name=l104 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3650 3420 0 0 {name=_388_}
N 3690 3380 3705 3380 {}
C {devices/lab_pin.sym} 3705 3380 0 0 {name=l105 lab=VDD}
N 3690 3460 3705 3460 {}
C {devices/lab_pin.sym} 3705 3460 0 0 {name=l106 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3650 3230 0 0 {name=_389_}
N 3690 3190 3705 3190 {}
C {devices/lab_pin.sym} 3705 3190 0 0 {name=l107 lab=VDD}
N 3690 3270 3705 3270 {}
C {devices/lab_pin.sym} 3705 3270 0 0 {name=l108 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3650 2850 0 0 {name=_390_}
N 3690 2810 3705 2810 {}
C {devices/lab_pin.sym} 3705 2810 0 0 {name=l109 lab=VDD}
N 3690 2890 3705 2890 {}
C {devices/lab_pin.sym} 3705 2890 0 0 {name=l110 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3650 2280 0 0 {name=_391_}
N 3690 2240 3705 2240 {}
C {devices/lab_pin.sym} 3705 2240 0 0 {name=l111 lab=VDD}
N 3690 2320 3705 2320 {}
C {devices/lab_pin.sym} 3705 2320 0 0 {name=l112 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3650 2090 0 0 {name=_392_}
N 3690 2050 3705 2050 {}
C {devices/lab_pin.sym} 3705 2050 0 0 {name=l113 lab=VDD}
N 3690 2130 3705 2130 {}
C {devices/lab_pin.sym} 3705 2130 0 0 {name=l114 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3650 1710 0 0 {name=_393_}
N 3690 1670 3705 1670 {}
C {devices/lab_pin.sym} 3705 1670 0 0 {name=l115 lab=VDD}
N 3690 1750 3705 1750 {}
C {devices/lab_pin.sym} 3705 1750 0 0 {name=l116 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3650 760 0 0 {name=_394_}
N 3680 700 3680 685 {}
C {devices/lab_pin.sym} 3680 685 0 0 {name=l117 lab=VDD}
N 3680 820 3680 835 {}
C {devices/lab_pin.sym} 3680 835 0 0 {name=l118 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 3040 0 0 {name=_395_}
N 2030 2980 2030 2965 {}
C {devices/lab_pin.sym} 2030 2965 0 0 {name=l119 lab=VDD}
N 2030 3100 2030 3115 {}
C {devices/lab_pin.sym} 2030 3115 0 0 {name=l120 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 2550 1140 0 0 {name=_396_}
N 2580 1080 2580 1065 {}
C {devices/lab_pin.sym} 2580 1065 0 0 {name=l121 lab=VDD}
N 2580 1200 2580 1215 {}
C {devices/lab_pin.sym} 2580 1215 0 0 {name=l122 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2550 190 0 0 {name=_397_}
N 2580 130 2580 115 {}
C {devices/lab_pin.sym} 2580 115 0 0 {name=l123 lab=VDD}
N 2580 250 2580 265 {}
C {devices/lab_pin.sym} 2580 265 0 0 {name=l124 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3100 190 0 0 {name=_398_}
N 3130 130 3130 115 {}
C {devices/lab_pin.sym} 3130 115 0 0 {name=l125 lab=VDD}
N 3130 250 3130 265 {}
C {devices/lab_pin.sym} 3130 265 0 0 {name=l126 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 570 0 0 {name=_399_}
N 4230 510 4230 495 {}
C {devices/lab_pin.sym} 4230 495 0 0 {name=l127 lab=VDD}
N 4230 630 4230 645 {}
C {devices/lab_pin.sym} 4230 645 0 0 {name=l128 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 4750 760 0 0 {name=_400_}
N 4780 700 4780 685 {}
C {devices/lab_pin.sym} 4780 685 0 0 {name=l129 lab=VDD}
N 4780 820 4780 835 {}
C {devices/lab_pin.sym} 4780 835 0 0 {name=l130 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 5300 760 0 0 {name=_401_}
N 5330 700 5330 685 {}
C {devices/lab_pin.sym} 5330 685 0 0 {name=l131 lab=VDD}
N 5330 820 5330 835 {}
C {devices/lab_pin.sym} 5330 835 0 0 {name=l132 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 3100 1140 0 0 {name=_402_}
N 3130 1080 3130 1065 {}
C {devices/lab_pin.sym} 3130 1065 0 0 {name=l133 lab=VDD}
N 3130 1200 3130 1215 {}
C {devices/lab_pin.sym} 3130 1215 0 0 {name=l134 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3650 190 0 0 {name=_403_}
N 3680 130 3680 115 {}
C {devices/lab_pin.sym} 3680 115 0 0 {name=l135 lab=VDD}
N 3680 250 3680 265 {}
C {devices/lab_pin.sym} 3680 265 0 0 {name=l136 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 380 0 0 {name=_404_}
N 2030 320 2030 305 {}
C {devices/lab_pin.sym} 2030 305 0 0 {name=l137 lab=VDD}
N 2030 440 2030 455 {}
C {devices/lab_pin.sym} 2030 455 0 0 {name=l138 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 2550 380 0 0 {name=_405_}
N 2580 320 2580 305 {}
C {devices/lab_pin.sym} 2580 305 0 0 {name=l139 lab=VDD}
N 2580 440 2580 455 {}
C {devices/lab_pin.sym} 2580 455 0 0 {name=l140 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 4750 190 0 0 {name=_406_}
N 4780 130 4780 115 {}
C {devices/lab_pin.sym} 4780 115 0 0 {name=l141 lab=VDD}
N 4780 250 4780 265 {}
C {devices/lab_pin.sym} 4780 265 0 0 {name=l142 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 5300 190 0 0 {name=_407_}
N 5330 130 5330 115 {}
C {devices/lab_pin.sym} 5330 115 0 0 {name=l143 lab=VDD}
N 5330 250 5330 265 {}
C {devices/lab_pin.sym} 5330 265 0 0 {name=l144 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2550 2090 0 0 {name=_408_}
N 2580 2030 2580 2015 {}
C {devices/lab_pin.sym} 2580 2015 0 0 {name=l145 lab=VDD}
N 2580 2150 2580 2165 {}
C {devices/lab_pin.sym} 2580 2165 0 0 {name=l146 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 2090 0 0 {name=_409_}
N 3140 2050 3155 2050 {}
C {devices/lab_pin.sym} 3155 2050 0 0 {name=l147 lab=VDD}
N 3140 2130 3155 2130 {}
C {devices/lab_pin.sym} 3155 2130 0 0 {name=l148 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3650 1520 0 0 {name=_410_}
N 3680 1460 3680 1445 {}
C {devices/lab_pin.sym} 3680 1445 0 0 {name=l149 lab=VDD}
N 3680 1580 3680 1595 {}
C {devices/lab_pin.sym} 3680 1595 0 0 {name=l150 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3650 3990 0 0 {name=_411_}
N 3690 3950 3705 3950 {}
C {devices/lab_pin.sym} 3705 3950 0 0 {name=l151 lab=VDD}
N 3690 4030 3705 4030 {}
C {devices/lab_pin.sym} 3705 4030 0 0 {name=l152 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 3230 0 0 {name=_412_}
N 3140 3190 3155 3190 {}
C {devices/lab_pin.sym} 3155 3190 0 0 {name=l153 lab=VDD}
N 3140 3270 3155 3270 {}
C {devices/lab_pin.sym} 3155 3270 0 0 {name=l154 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2000 570 0 0 {name=_413_}
N 2030 510 2030 495 {}
C {devices/lab_pin.sym} 2030 495 0 0 {name=l155 lab=VDD}
N 2030 630 2030 645 {}
C {devices/lab_pin.sym} 2030 645 0 0 {name=l156 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 760 0 0 {name=_414_}
N 2030 700 2030 685 {}
C {devices/lab_pin.sym} 2030 685 0 0 {name=l157 lab=VDD}
N 2030 820 2030 835 {}
C {devices/lab_pin.sym} 2030 835 0 0 {name=l158 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 950 0 0 {name=_415_}
N 2030 890 2030 875 {}
C {devices/lab_pin.sym} 2030 875 0 0 {name=l159 lab=VDD}
N 2030 1010 2030 1025 {}
C {devices/lab_pin.sym} 2030 1025 0 0 {name=l160 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2000 1140 0 0 {name=_416_}
N 2030 1080 2030 1065 {}
C {devices/lab_pin.sym} 2030 1065 0 0 {name=l161 lab=VDD}
N 2030 1200 2030 1215 {}
C {devices/lab_pin.sym} 2030 1215 0 0 {name=l162 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND4.sym} 2550 570 0 0 {name=_417_}
N 2580 510 2580 495 {}
C {devices/lab_pin.sym} 2580 495 0 0 {name=l163 lab=VDD}
N 2580 630 2580 645 {}
C {devices/lab_pin.sym} 2580 645 0 0 {name=l164 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3100 380 0 0 {name=_418_}
N 3130 320 3130 305 {}
C {devices/lab_pin.sym} 3130 305 0 0 {name=l165 lab=VDD}
N 3130 440 3130 455 {}
C {devices/lab_pin.sym} 3130 455 0 0 {name=l166 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3650 950 0 0 {name=_419_}
N 3680 890 3680 875 {}
C {devices/lab_pin.sym} 3680 875 0 0 {name=l167 lab=VDD}
N 3680 1010 3680 1025 {}
C {devices/lab_pin.sym} 3680 1025 0 0 {name=l168 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 1520 0 0 {name=_420_}
N 2030 1460 2030 1445 {}
C {devices/lab_pin.sym} 2030 1445 0 0 {name=l169 lab=VDD}
N 2030 1580 2030 1595 {}
C {devices/lab_pin.sym} 2030 1595 0 0 {name=l170 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2000 1710 0 0 {name=_421_}
N 2030 1650 2030 1635 {}
C {devices/lab_pin.sym} 2030 1635 0 0 {name=l171 lab=VDD}
N 2030 1770 2030 1785 {}
C {devices/lab_pin.sym} 2030 1785 0 0 {name=l172 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2000 1900 0 0 {name=_422_}
N 2030 1840 2030 1825 {}
C {devices/lab_pin.sym} 2030 1825 0 0 {name=l173 lab=VDD}
N 2030 1960 2030 1975 {}
C {devices/lab_pin.sym} 2030 1975 0 0 {name=l174 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 2090 0 0 {name=_423_}
N 2030 2030 2030 2015 {}
C {devices/lab_pin.sym} 2030 2015 0 0 {name=l175 lab=VDD}
N 2030 2150 2030 2165 {}
C {devices/lab_pin.sym} 2030 2165 0 0 {name=l176 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND4.sym} 2550 760 0 0 {name=_424_}
N 2580 700 2580 685 {}
C {devices/lab_pin.sym} 2580 685 0 0 {name=l177 lab=VDD}
N 2580 820 2580 835 {}
C {devices/lab_pin.sym} 2580 835 0 0 {name=l178 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3100 570 0 0 {name=_425_}
N 3130 510 3130 495 {}
C {devices/lab_pin.sym} 3130 495 0 0 {name=l179 lab=VDD}
N 3130 630 3130 645 {}
C {devices/lab_pin.sym} 3130 645 0 0 {name=l180 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 3650 1140 0 0 {name=_426_}
N 3680 1080 3680 1065 {}
C {devices/lab_pin.sym} 3680 1065 0 0 {name=l181 lab=VDD}
N 3680 1200 3680 1215 {}
C {devices/lab_pin.sym} 3680 1215 0 0 {name=l182 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 760 0 0 {name=_427_}
N 4230 700 4230 685 {}
C {devices/lab_pin.sym} 4230 685 0 0 {name=l183 lab=VDD}
N 4230 820 4230 835 {}
C {devices/lab_pin.sym} 4230 835 0 0 {name=l184 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 4750 570 0 0 {name=_428_}
N 4780 510 4780 495 {}
C {devices/lab_pin.sym} 4780 495 0 0 {name=l185 lab=VDD}
N 4780 630 4780 645 {}
C {devices/lab_pin.sym} 4780 645 0 0 {name=l186 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/AND2_X1.sym} 2550 1520 0 0 {name=_429_}
N 2580 1460 2580 1445 {}
C {devices/lab_pin.sym} 2580 1445 0 0 {name=l187 lab=VDD}
N 2580 1580 2580 1595 {}
C {devices/lab_pin.sym} 2580 1595 0 0 {name=l188 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR3.sym} 4200 950 0 0 {name=_430_}
N 4230 890 4230 875 {}
C {devices/lab_pin.sym} 4230 875 0 0 {name=l189 lab=VDD}
N 4230 1010 4230 1025 {}
C {devices/lab_pin.sym} 4230 1025 0 0 {name=l190 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 5300 570 0 0 {name=_431_}
N 5330 510 5330 495 {}
C {devices/lab_pin.sym} 5330 495 0 0 {name=l191 lab=VDD}
N 5330 630 5330 645 {}
C {devices/lab_pin.sym} 5330 645 0 0 {name=l192 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 4200 1520 0 0 {name=_432_}
N 4230 1460 4230 1445 {}
C {devices/lab_pin.sym} 4230 1445 0 0 {name=l193 lab=VDD}
N 4230 1580 4230 1595 {}
C {devices/lab_pin.sym} 4230 1595 0 0 {name=l194 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 2000 3610 0 0 {name=_433_}
N 2030 3550 2030 3535 {}
C {devices/lab_pin.sym} 2030 3535 0 0 {name=l195 lab=VDD}
N 2030 3670 2030 3685 {}
C {devices/lab_pin.sym} 2030 3685 0 0 {name=l196 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 2550 1900 0 0 {name=_434_}
N 2580 1840 2580 1825 {}
C {devices/lab_pin.sym} 2580 1825 0 0 {name=l197 lab=VDD}
N 2580 1960 2580 1975 {}
C {devices/lab_pin.sym} 2580 1975 0 0 {name=l198 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR2.sym} 3100 2280 0 0 {name=_435_}
N 3130 2220 3130 2205 {}
C {devices/lab_pin.sym} 3130 2205 0 0 {name=l199 lab=VDD}
N 3130 2340 3130 2355 {}
C {devices/lab_pin.sym} 3130 2355 0 0 {name=l200 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 4200 190 0 0 {name=_436_}
N 4230 130 4230 115 {}
C {devices/lab_pin.sym} 4230 115 0 0 {name=l201 lab=VDD}
N 4230 250 4230 265 {}
C {devices/lab_pin.sym} 4230 265 0 0 {name=l202 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 5300 0 0 0 {name=_437_}
N 5340 -40 5355 -40 {}
C {devices/lab_pin.sym} 5355 -40 0 0 {name=l203 lab=VDD}
N 5340 40 5355 40 {}
C {devices/lab_pin.sym} 5355 40 0 0 {name=l204 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND3.sym} 2550 1710 0 0 {name=_438_}
N 2580 1650 2580 1635 {}
C {devices/lab_pin.sym} 2580 1635 0 0 {name=l205 lab=VDD}
N 2580 1770 2580 1785 {}
C {devices/lab_pin.sym} 2580 1785 0 0 {name=l206 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NAND2.sym} 3100 1710 0 0 {name=_439_}
N 3130 1650 3130 1635 {}
C {devices/lab_pin.sym} 3130 1635 0 0 {name=l207 lab=VDD}
N 3130 1770 3130 1785 {}
C {devices/lab_pin.sym} 3130 1785 0 0 {name=l208 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/OR4.sym} 1450 3040 0 0 {name=_440_}
N 1480 2980 1480 2965 {}
C {devices/lab_pin.sym} 1480 2965 0 0 {name=l209 lab=VDD}
N 1480 3100 1480 3115 {}
C {devices/lab_pin.sym} 1480 3115 0 0 {name=l210 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR4.sym} 2000 3800 0 0 {name=_441_}
N 2030 3740 2030 3725 {}
C {devices/lab_pin.sym} 2030 3725 0 0 {name=l211 lab=VDD}
N 2030 3860 2030 3875 {}
C {devices/lab_pin.sym} 2030 3875 0 0 {name=l212 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/MUX2.sym} 3100 2660 0 0 {name=_442_}
N 3140 2620 3155 2620 {}
C {devices/lab_pin.sym} 3155 2620 0 0 {name=l213 lab=VDD}
N 3140 2700 3155 2700 {}
C {devices/lab_pin.sym} 3155 2700 0 0 {name=l214 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 2470 0 0 {name=_443_}
N 3620 2410 3620 2395 {}
C {devices/lab_pin.sym} 3620 2395 0 0 {name=l215 lab=VDD}
N 3620 2530 3620 2545 {}
C {devices/lab_pin.sym} 3620 2545 0 0 {name=l216 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 5850 760 0 0 {name=_444_}
N 5820 700 5820 685 {}
C {devices/lab_pin.sym} 5820 685 0 0 {name=l217 lab=VDD}
N 5820 820 5820 835 {}
C {devices/lab_pin.sym} 5820 835 0 0 {name=l218 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 5850 190 0 0 {name=_445_}
N 5820 130 5820 115 {}
C {devices/lab_pin.sym} 5820 115 0 0 {name=l219 lab=VDD}
N 5820 250 5820 265 {}
C {devices/lab_pin.sym} 5820 265 0 0 {name=l220 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 3610 0 0 {name=_446_}
N 3620 3550 3620 3535 {}
C {devices/lab_pin.sym} 3620 3535 0 0 {name=l221 lab=VDD}
N 3620 3670 3620 3685 {}
C {devices/lab_pin.sym} 3620 3685 0 0 {name=l222 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 1140 0 0 {name=_447_}
N 4720 1080 4720 1065 {}
C {devices/lab_pin.sym} 4720 1065 0 0 {name=l223 lab=VDD}
N 4720 1200 4720 1215 {}
C {devices/lab_pin.sym} 4720 1215 0 0 {name=l224 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 1330 0 0 {name=_448_}
N 4720 1270 4720 1255 {}
C {devices/lab_pin.sym} 4720 1255 0 0 {name=l225 lab=VDD}
N 4720 1390 4720 1405 {}
C {devices/lab_pin.sym} 4720 1405 0 0 {name=l226 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 1520 0 0 {name=_449_}
N 4720 1460 4720 1445 {}
C {devices/lab_pin.sym} 4720 1445 0 0 {name=l227 lab=VDD}
N 4720 1580 4720 1595 {}
C {devices/lab_pin.sym} 4720 1595 0 0 {name=l228 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 1900 0 0 {name=_450_}
N 4720 1840 4720 1825 {}
C {devices/lab_pin.sym} 4720 1825 0 0 {name=l229 lab=VDD}
N 4720 1960 4720 1975 {}
C {devices/lab_pin.sym} 4720 1975 0 0 {name=l230 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 2090 0 0 {name=_451_}
N 4720 2030 4720 2015 {}
C {devices/lab_pin.sym} 4720 2015 0 0 {name=l231 lab=VDD}
N 4720 2150 4720 2165 {}
C {devices/lab_pin.sym} 4720 2165 0 0 {name=l232 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 2280 0 0 {name=_452_}
N 4720 2220 4720 2205 {}
C {devices/lab_pin.sym} 4720 2205 0 0 {name=l233 lab=VDD}
N 4720 2340 4720 2355 {}
C {devices/lab_pin.sym} 4720 2355 0 0 {name=l234 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 2470 0 0 {name=_453_}
N 4720 2410 4720 2395 {}
C {devices/lab_pin.sym} 4720 2395 0 0 {name=l235 lab=VDD}
N 4720 2530 4720 2545 {}
C {devices/lab_pin.sym} 4720 2545 0 0 {name=l236 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 2660 0 0 {name=_454_}
N 4720 2600 4720 2585 {}
C {devices/lab_pin.sym} 4720 2585 0 0 {name=l237 lab=VDD}
N 4720 2720 4720 2735 {}
C {devices/lab_pin.sym} 4720 2735 0 0 {name=l238 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 2660 0 0 {name=_455_}
N 3620 2600 3620 2585 {}
C {devices/lab_pin.sym} 3620 2585 0 0 {name=l239 lab=VDD}
N 3620 2720 3620 2735 {}
C {devices/lab_pin.sym} 3620 2735 0 0 {name=l240 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 4180 0 0 {name=_456_}
N 3620 4120 3620 4105 {}
C {devices/lab_pin.sym} 3620 4105 0 0 {name=l241 lab=VDD}
N 3620 4240 3620 4255 {}
C {devices/lab_pin.sym} 3620 4255 0 0 {name=l242 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 4560 0 0 {name=_457_}
N 3620 4500 3620 4485 {}
C {devices/lab_pin.sym} 3620 4485 0 0 {name=l243 lab=VDD}
N 3620 4620 3620 4635 {}
C {devices/lab_pin.sym} 3620 4635 0 0 {name=l244 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 4750 0 0 {name=_458_}
N 3620 4690 3620 4675 {}
C {devices/lab_pin.sym} 3620 4675 0 0 {name=l245 lab=VDD}
N 3620 4810 3620 4825 {}
C {devices/lab_pin.sym} 3620 4825 0 0 {name=l246 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 5510 0 0 {name=_459_}
N 3620 5450 3620 5435 {}
C {devices/lab_pin.sym} 3620 5435 0 0 {name=l247 lab=VDD}
N 3620 5570 3620 5585 {}
C {devices/lab_pin.sym} 3620 5585 0 0 {name=l248 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 5320 0 0 {name=_460_}
N 3620 5260 3620 5245 {}
C {devices/lab_pin.sym} 3620 5245 0 0 {name=l249 lab=VDD}
N 3620 5380 3620 5395 {}
C {devices/lab_pin.sym} 3620 5395 0 0 {name=l250 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 5700 0 0 {name=_461_}
N 3620 5640 3620 5625 {}
C {devices/lab_pin.sym} 3620 5625 0 0 {name=l251 lab=VDD}
N 3620 5760 3620 5775 {}
C {devices/lab_pin.sym} 3620 5775 0 0 {name=l252 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 5130 0 0 {name=_462_}
N 3620 5070 3620 5055 {}
C {devices/lab_pin.sym} 3620 5055 0 0 {name=l253 lab=VDD}
N 3620 5190 3620 5205 {}
C {devices/lab_pin.sym} 3620 5205 0 0 {name=l254 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 4750 1710 0 0 {name=_463_}
N 4720 1650 4720 1635 {}
C {devices/lab_pin.sym} 4720 1635 0 0 {name=l255 lab=VDD}
N 4720 1770 4720 1785 {}
C {devices/lab_pin.sym} 4720 1785 0 0 {name=l256 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 5300 950 0 0 {name=_464_}
N 5270 890 5270 875 {}
C {devices/lab_pin.sym} 5270 875 0 0 {name=l257 lab=VDD}
N 5270 1010 5270 1025 {}
C {devices/lab_pin.sym} 5270 1025 0 0 {name=l258 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 5850 380 0 0 {name=_465_}
N 5820 320 5820 305 {}
C {devices/lab_pin.sym} 5820 305 0 0 {name=l259 lab=VDD}
N 5820 440 5820 455 {}
C {devices/lab_pin.sym} 5820 455 0 0 {name=l260 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 5850 0 0 0 {name=_466_}
N 5820 -60 5820 -75 {}
C {devices/lab_pin.sym} 5820 -75 0 0 {name=l261 lab=VDD}
N 5820 60 5820 75 {}
C {devices/lab_pin.sym} 5820 75 0 0 {name=l262 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 4370 0 0 {name=_467_}
N 3620 4310 3620 4295 {}
C {devices/lab_pin.sym} 3620 4295 0 0 {name=l263 lab=VDD}
N 3620 4430 3620 4445 {}
C {devices/lab_pin.sym} 3620 4445 0 0 {name=l264 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 5850 570 0 0 {name=_468_}
N 5820 510 5820 495 {}
C {devices/lab_pin.sym} 5820 495 0 0 {name=l265 lab=VDD}
N 5820 630 5820 645 {}
C {devices/lab_pin.sym} 5820 645 0 0 {name=l266 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 6080 0 0 {name=_469_}
N 3620 6020 3620 6005 {}
C {devices/lab_pin.sym} 3620 6005 0 0 {name=l267 lab=VDD}
N 3620 6140 3620 6155 {}
C {devices/lab_pin.sym} 3620 6155 0 0 {name=l268 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 6270 0 0 {name=_470_}
N 3620 6210 3620 6195 {}
C {devices/lab_pin.sym} 3620 6195 0 0 {name=l269 lab=VDD}
N 3620 6330 3620 6345 {}
C {devices/lab_pin.sym} 3620 6345 0 0 {name=l270 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 5890 0 0 {name=_471_}
N 3620 5830 3620 5815 {}
C {devices/lab_pin.sym} 3620 5815 0 0 {name=l271 lab=VDD}
N 3620 5950 3620 5965 {}
C {devices/lab_pin.sym} 3620 5965 0 0 {name=l272 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 6840 0 0 {name=_472_}
N 3620 6780 3620 6765 {}
C {devices/lab_pin.sym} 3620 6765 0 0 {name=l273 lab=VDD}
N 3620 6900 3620 6915 {}
C {devices/lab_pin.sym} 3620 6915 0 0 {name=l274 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 6460 0 0 {name=_473_}
N 3620 6400 3620 6385 {}
C {devices/lab_pin.sym} 3620 6385 0 0 {name=l275 lab=VDD}
N 3620 6520 3620 6535 {}
C {devices/lab_pin.sym} 3620 6535 0 0 {name=l276 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 6650 0 0 {name=_474_}
N 3620 6590 3620 6575 {}
C {devices/lab_pin.sym} 3620 6575 0 0 {name=l277 lab=VDD}
N 3620 6710 3620 6725 {}
C {devices/lab_pin.sym} 3620 6725 0 0 {name=l278 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DFFR.sym} 3650 4940 0 0 {name=_475_}
N 3620 4880 3620 4865 {}
C {devices/lab_pin.sym} 3620 4865 0 0 {name=l279 lab=VDD}
N 3620 5000 3620 5015 {}
C {devices/lab_pin.sym} 3620 5015 0 0 {name=l280 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/DEL1.sym} 1450 2850 0 0 {name=u_del_sda}
N 1480 2810 1480 2795 {}
C {devices/lab_pin.sym} 1480 2795 0 0 {name=l281 lab=VDD}
N 1480 2890 1480 2905 {}
C {devices/lab_pin.sym} 1480 2905 0 0 {name=l282 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/INV_X1.sym} 1450 1710 0 0 {name=u_inv_scl}
N 1480 1670 1480 1655 {}
C {devices/lab_pin.sym} 1480 1655 0 0 {name=l283 lab=VDD}
N 1480 1750 1480 1765 {}
C {devices/lab_pin.sym} 1480 1765 0 0 {name=l284 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3650 3040 0 0 {name=u_lat_q}
N 3680 2980 3680 2965 {}
C {devices/lab_pin.sym} 3680 2965 0 0 {name=l285 lab=VDD}
N 3680 3100 3680 3115 {}
C {devices/lab_pin.sym} 3680 3115 0 0 {name=l286 lab=GND}
C {/Users/okamura/Dropbox/91_OpenPDK/TR-1um/libs.tech/xschem/TR-1um_5_stdcell/NOR2.sym} 3100 1900 0 0 {name=u_lat_qn}
N 3130 1840 3130 1825 {}
C {devices/lab_pin.sym} 3130 1825 0 0 {name=l287 lab=VDD}
N 3130 1960 3130 1975 {}
C {devices/lab_pin.sym} 3130 1975 0 0 {name=l288 lab=GND}
C {devices/ipin.sym} 350 190 0 0 {name=io_rst_n lab=rst_n}
C {devices/ipin.sym} 350 1710 0 0 {name=io_scl lab=scl}
C {devices/ipin.sym} 350 760 0 0 {name=io_sda_in lab=sda_in}
C {devices/ipin.sym} 350 0 0 0 {name=io_tx_data_0_ lab=tx_data[0]}
C {devices/ipin.sym} 350 380 0 0 {name=io_tx_data_1_ lab=tx_data[1]}
C {devices/ipin.sym} 350 570 0 0 {name=io_tx_data_2_ lab=tx_data[2]}
C {devices/ipin.sym} 350 1140 0 0 {name=io_tx_data_3_ lab=tx_data[3]}
C {devices/ipin.sym} 350 1330 0 0 {name=io_tx_data_4_ lab=tx_data[4]}
C {devices/ipin.sym} 350 1520 0 0 {name=io_tx_data_5_ lab=tx_data[5]}
C {devices/ipin.sym} 350 1900 0 0 {name=io_tx_data_6_ lab=tx_data[6]}
C {devices/ipin.sym} 350 950 0 0 {name=io_tx_data_7_ lab=tx_data[7]}
C {devices/opin.sym} 6400 0 0 0 {name=io_sda_oe lab=sda_oe}
C {devices/opin.sym} 6400 380 0 0 {name=io_rx_data_0_ lab=rx_data[0]}
C {devices/opin.sym} 6400 950 0 0 {name=io_rx_data_1_ lab=rx_data[1]}
C {devices/opin.sym} 6400 1330 0 0 {name=io_rx_data_2_ lab=rx_data[2]}
C {devices/opin.sym} 6400 1520 0 0 {name=io_rx_data_3_ lab=rx_data[3]}
C {devices/opin.sym} 6400 2090 0 0 {name=io_rx_data_4_ lab=rx_data[4]}
C {devices/opin.sym} 6400 1900 0 0 {name=io_rx_data_5_ lab=rx_data[5]}
C {devices/opin.sym} 6400 2280 0 0 {name=io_rx_data_6_ lab=rx_data[6]}
C {devices/opin.sym} 6400 1710 0 0 {name=io_rx_data_7_ lab=rx_data[7]}
C {devices/opin.sym} 6400 190 0 0 {name=io_rx_valid lab=rx_valid}
C {devices/opin.sym} 6400 1140 0 0 {name=io_addr_match lab=addr_match}
C {devices/opin.sym} 6400 760 0 0 {name=io_rw lab=rw}
C {devices/opin.sym} 6400 570 0 0 {name=io_busy lab=busy}
C {devices/iopin.sym} 350 -260 0 0 {name=io_VDD lab=VDD}
C {devices/iopin.sym} 350 -200 0 0 {name=io_GND lab=GND}
N 5430 570 5601 570 {}
N 5601 570 5601 540 {}
N 5601 540 5820 540 {}
N 5880 10 5888 10 {}
N 5888 10 5888 760 {}
N 5888 760 1430 760 {}
N 3680 3620 3700 3620 {}
N 3700 3620 3700 2660 {}
N 3700 2660 1430 2660 {}
N 5880 200 5912 200 {}
N 5912 200 5912 1310 {}
N 5912 1310 1980 1310 {}
N 5880 200 5924 200 {}
N 5924 200 5924 170 {}
N 5924 170 1980 170 {}
N 5880 770 5936 770 {}
N 5936 770 5936 2490 {}
N 5936 2490 1430 2490 {}
N 4780 1720 4764 1720 {}
N 4764 1720 4764 1130 {}
N 4764 1130 1440 1130 {}
N 4780 1720 4776 1720 {}
N 4776 1720 4776 930 {}
N 4776 930 3080 930 {}
N 5330 960 5338 960 {}
N 5338 960 5338 1170 {}
N 5338 1170 1440 1170 {}
N 5880 390 5900 390 {}
N 5900 390 5900 1150 {}
N 5900 1150 1440 1150 {}
N 5880 390 5912 390 {}
N 5912 390 5912 360 {}
N 5912 360 3080 360 {}
N 3680 6470 3724 6470 {}
N 3724 6470 3724 3030 {}
N 3724 3030 1440 3030 {}
N 3680 4950 3736 4950 {}
N 3736 4950 3736 3010 {}
N 3736 3010 1440 3010 {}
N 3680 2480 3664 2480 {}
N 3664 2480 3664 2260 {}
N 3664 2260 1980 2260 {}
N 3680 2480 3676 2480 {}
N 3676 2480 3676 930 {}
N 3676 930 1430 930 {}
N 5410 380 5603 380 {}
N 5603 380 5603 350 {}
N 5603 350 5820 350 {}
N 4880 950 5075 950 {}
N 5075 950 5075 920 {}
N 5075 920 5270 920 {}
N 4330 1330 4537 1330 {}
N 4537 1330 4537 1680 {}
N 4537 1680 4720 1680 {}
N 3170 3800 3419 3800 {}
N 3419 3800 3419 5670 {}
N 3419 5670 3620 5670 {}
N 3170 3420 3431 3420 {}
N 3431 3420 3431 5290 {}
N 3431 5290 3620 5290 {}
N 3170 3610 3359 3610 {}
N 3359 3610 3359 5480 {}
N 3359 5480 3620 5480 {}
N 3170 3040 3371 3040 {}
N 3371 3040 3371 4720 {}
N 3371 4720 3620 4720 {}
N 3170 2850 3383 2850 {}
N 3383 2850 3383 4530 {}
N 3383 4530 3620 4530 {}
N 3170 2470 3395 2470 {}
N 3395 2470 3395 4150 {}
N 3395 4150 3620 4150 {}
N 3170 1330 3407 1330 {}
N 3407 1330 3407 2630 {}
N 3407 2630 3620 2630 {}
N 3720 3800 4244 3800 {}
N 4244 3800 4244 2440 {}
N 4244 2440 4720 2440 {}
N 3720 3420 4256 3420 {}
N 4256 3420 4256 2250 {}
N 4256 2250 4720 2250 {}
N 3720 3230 4184 3230 {}
N 4184 3230 4184 2060 {}
N 4184 2060 4720 2060 {}
N 3720 2850 4196 2850 {}
N 4196 2850 4196 1870 {}
N 4196 1870 4720 1870 {}
N 3720 2280 4208 2280 {}
N 4208 2280 4208 1490 {}
N 4208 1490 4720 1490 {}
N 3720 2090 4220 2090 {}
N 4220 2090 4220 1300 {}
N 4220 1300 4720 1300 {}
N 3720 1710 4232 1710 {}
N 4232 1710 4232 1110 {}
N 4232 1110 4720 1110 {}
N 5410 760 5639 760 {}
N 5639 760 5639 730 {}
N 5639 730 5820 730 {}
N 3210 1140 3451 1140 {}
N 3451 1140 3451 2440 {}
N 3451 2440 3620 2440 {}
N 5410 190 5579 190 {}
N 5579 190 5579 160 {}
N 5579 160 5820 160 {}
N 3170 2090 3371 2090 {}
N 3371 2090 3371 3580 {}
N 3371 3580 3620 3580 {}
N 3720 3990 4208 3990 {}
N 4208 3990 4208 2630 {}
N 4208 2630 4720 2630 {}
N 3170 3230 3395 3230 {}
N 3395 3230 3395 5100 {}
N 3395 5100 3620 5100 {}
N 5370 0 5607 0 {}
N 5607 0 5607 -30 {}
N 5607 -30 5820 -30 {}
N 3170 2660 3419 2660 {}
N 3419 2660 3419 4340 {}
N 3419 4340 3620 4340 {}
N 2110 1330 2356 1330 {}
N 2356 1330 2356 950 {}
N 2356 950 2530 950 {}
N 2110 1330 2284 1330 {}
N 2284 1330 2284 20 {}
N 2284 20 2530 20 {}
N 2110 1330 2296 1330 {}
N 2296 1330 2296 1350 {}
N 2296 1350 2530 1350 {}
N 2110 1330 3413 1330 {}
N 3413 1330 3413 160 {}
N 3413 160 4740 160 {}
N 2110 1330 3420 1330 {}
N 3420 1330 3420 550 {}
N 3420 550 4730 550 {}
N 2650 950 3152 950 {}
N 3152 950 3152 550 {}
N 3152 550 3630 550 {}
N 2650 950 3164 950 {}
N 3164 950 3164 -20 {}
N 3164 -20 3630 -20 {}
N 2650 950 2901 950 {}
N 2901 950 2901 1500 {}
N 2901 1500 3080 1500 {}
N 2660 0 2834 0 {}
N 2834 0 2834 -20 {}
N 2834 -20 3080 -20 {}
N 2660 1330 2851 1330 {}
N 2851 1330 2851 750 {}
N 2851 750 3090 750 {}
N 2660 1330 2858 1330 {}
N 2858 1330 2858 970 {}
N 2858 970 3080 970 {}
N 2660 1330 2870 1330 {}
N 2870 1330 2870 1120 {}
N 2870 1120 3080 1120 {}
N 1560 950 1782 950 {}
N 1782 950 1782 210 {}
N 1782 210 1980 210 {}
N 1560 950 1794 950 {}
N 1794 950 1794 2490 {}
N 1794 2490 1980 2490 {}
N 2110 190 2636 190 {}
N 2636 190 2636 770 {}
N 2636 770 3090 770 {}
N 2110 190 2284 190 {}
N 2284 190 2284 210 {}
N 2284 210 2530 210 {}
N 2110 190 3401 190 {}
N 3401 190 3401 180 {}
N 3401 180 4740 180 {}
N 2110 2470 2588 2470 {}
N 2588 2470 2588 790 {}
N 2588 790 3090 790 {}
N 2110 2470 2320 2470 {}
N 2320 2470 2320 1120 {}
N 2320 1120 2530 1120 {}
N 2110 2470 2332 2470 {}
N 2332 2470 2332 360 {}
N 2332 360 2530 360 {}
N 2110 2470 2344 2470 {}
N 2344 2470 2344 1540 {}
N 2344 1540 2530 1540 {}
N 3210 760 3456 760 {}
N 3456 760 3456 380 {}
N 3456 380 3630 380 {}
N 3210 760 3384 760 {}
N 3384 760 3384 1350 {}
N 3384 1350 3630 1350 {}
N 3210 760 3396 760 {}
N 3396 760 3396 1920 {}
N 3396 1920 3630 1920 {}
N 3750 380 4228 380 {}
N 4228 380 4228 -20 {}
N 4228 -20 4730 -20 {}
N 3750 380 3965 380 {}
N 3965 380 3965 550 {}
N 3965 550 4180 550 {}
N 1560 380 1782 380 {}
N 1782 380 1782 20 {}
N 1782 20 1980 20 {}
N 1560 380 2894 380 {}
N 2894 380 2894 360 {}
N 2894 360 4180 360 {}
N 1560 380 2906 380 {}
N 2906 380 2906 1120 {}
N 2906 1120 4180 1120 {}
N 1560 380 1734 380 {}
N 1734 380 1734 970 {}
N 1734 970 1980 970 {}
N 1560 380 1746 380 {}
N 1746 380 1746 2110 {}
N 1746 2110 1980 2110 {}
N 2130 0 3143 0 {}
N 3143 0 3143 -20 {}
N 3143 -20 4180 -20 {}
N 2130 0 3155 0 {}
N 3155 0 3155 170 {}
N 3155 170 4180 170 {}
N 1560 1140 2332 1140 {}
N 2332 1140 2332 20 {}
N 2332 20 3080 20 {}
N 1560 1140 2069 1140 {}
N 2069 1140 2069 2300 {}
N 2069 2300 2530 2300 {}
N 1560 1140 2356 1140 {}
N 2356 1140 2356 1160 {}
N 2356 1160 3080 1160 {}
N 1560 1140 2009 1140 {}
N 2009 1140 2009 2110 {}
N 2009 2110 2530 2110 {}
N 3210 0 3396 0 {}
N 3396 0 3396 590 {}
N 3396 590 3630 590 {}
N 3210 0 3408 0 {}
N 3408 0 3408 20 {}
N 3408 20 3630 20 {}
N 3210 0 3420 0 {}
N 3420 0 3420 780 {}
N 3420 780 3630 780 {}
N 3210 0 3707 0 {}
N 3707 0 3707 590 {}
N 3707 590 4180 590 {}
N 3210 0 3444 0 {}
N 3444 0 3444 210 {}
N 3444 210 3630 210 {}
N 3760 570 4006 570 {}
N 4006 570 4006 1140 {}
N 4006 1140 4180 1140 {}
N 3760 570 3934 570 {}
N 3934 570 3934 210 {}
N 3934 210 4180 210 {}
N 3780 0 3956 0 {}
N 3956 0 3956 20 {}
N 3956 20 4180 20 {}
N 3780 0 3968 0 {}
N 3968 0 3968 400 {}
N 3968 400 4180 400 {}
N 4330 0 4530 0 {}
N 4530 0 4530 20 {}
N 4530 20 4730 20 {}
N 4880 0 5092 0 {}
N 5092 0 5092 360 {}
N 5092 360 5280 360 {}
N 4880 0 5104 0 {}
N 5104 0 5104 20 {}
N 5104 20 5280 20 {}
N 4330 380 4566 380 {}
N 4566 380 4566 400 {}
N 4566 400 4730 400 {}
N 4880 380 5044 380 {}
N 5044 380 5044 400 {}
N 5044 400 5280 400 {}
N 3780 1330 4231 1330 {}
N 4231 1330 4231 930 {}
N 4231 930 4730 930 {}
N 1560 1520 2858 1520 {}
N 2858 1520 2858 1160 {}
N 2858 1160 4180 1160 {}
N 1560 1520 1770 1520 {}
N 1770 1520 1770 2640 {}
N 1770 2640 1980 2640 {}
N 1560 1520 1782 1520 {}
N 1782 1520 1782 780 {}
N 1782 780 1980 780 {}
N 1560 1520 1794 1520 {}
N 1794 1520 1794 1540 {}
N 1794 1540 1980 1540 {}
N 4310 1140 4556 1140 {}
N 4556 1140 4556 970 {}
N 4556 970 4730 970 {}
N 3780 1900 3944 1900 {}
N 3944 1900 3944 1310 {}
N 3944 1310 4180 1310 {}
N 3230 950 3681 950 {}
N 3681 950 3681 1350 {}
N 3681 1350 4180 1350 {}
N 2680 2280 2888 2280 {}
N 2888 2280 2888 3840 {}
N 2888 3840 3120 3840 {}
N 2680 2280 2900 2280 {}
N 2900 2280 2900 3460 {}
N 2900 3460 3120 3460 {}
N 2680 2280 2912 2280 {}
N 2912 2280 2912 3650 {}
N 2912 3650 3120 3650 {}
N 2680 2280 2924 2280 {}
N 2924 2280 2924 3080 {}
N 2924 3080 3120 3080 {}
N 2680 2280 2936 2280 {}
N 2936 2280 2936 2890 {}
N 2936 2890 3120 2890 {}
N 2680 2280 2864 2280 {}
N 2864 2280 2864 2510 {}
N 2864 2510 3120 2510 {}
N 2680 2280 2876 2280 {}
N 2876 2280 2876 1370 {}
N 2876 1370 3120 1370 {}
N 2680 2280 2868 2280 {}
N 2868 2280 2868 170 {}
N 2868 170 3080 170 {}
N 2680 2280 2900 2280 {}
N 2900 2280 2900 3270 {}
N 2900 3270 3120 3270 {}
N 1560 2280 1782 2280 {}
N 1782 2280 1782 2680 {}
N 1782 2680 1980 2680 {}
N 2130 2660 2629 2660 {}
N 2629 2660 2629 1540 {}
N 2629 1540 3080 1540 {}
N 2130 2660 3466 2660 {}
N 3466 2660 3466 570 {}
N 3466 570 4730 570 {}
N 3210 1520 3404 1520 {}
N 3404 1520 3404 3840 {}
N 3404 3840 3670 3840 {}
N 3210 1520 3416 1520 {}
N 3416 1520 3416 3460 {}
N 3416 3460 3670 3460 {}
N 3210 1520 3428 1520 {}
N 3428 1520 3428 3270 {}
N 3428 3270 3670 3270 {}
N 3210 1520 3440 1520 {}
N 3440 1520 3440 2890 {}
N 3440 2890 3670 2890 {}
N 3210 1520 3452 1520 {}
N 3452 1520 3452 2320 {}
N 3452 2320 3670 2320 {}
N 3210 1520 3464 1520 {}
N 3464 1520 3464 2130 {}
N 3464 2130 3670 2130 {}
N 3210 1520 3476 1520 {}
N 3476 1520 3476 1750 {}
N 3476 1750 3670 1750 {}
N 3210 1520 3384 1520 {}
N 3384 1520 3384 1540 {}
N 3384 1540 3630 1540 {}
N 3210 1520 3416 1520 {}
N 3416 1520 3416 4030 {}
N 3416 4030 3670 4030 {}
N 3760 760 4508 760 {}
N 4508 760 4508 740 {}
N 4508 740 5280 740 {}
N 2130 3040 2330 3040 {}
N 2330 3040 2330 1160 {}
N 2330 1160 2530 1160 {}
N 2660 1140 3712 1140 {}
N 3712 1140 3712 750 {}
N 3712 750 4740 750 {}
N 2680 190 2904 190 {}
N 2904 190 2904 210 {}
N 2904 210 3080 210 {}
N 3230 190 4021 190 {}
N 4021 190 4021 770 {}
N 4021 770 4740 770 {}
N 4330 570 4499 570 {}
N 4499 570 4499 790 {}
N 4499 790 4740 790 {}
N 4330 570 4511 570 {}
N 4511 570 4511 200 {}
N 4511 200 4740 200 {}
N 4860 760 5058 760 {}
N 5058 760 5058 780 {}
N 5058 780 5280 780 {}
N 3760 190 4520 190 {}
N 4520 190 4520 170 {}
N 4520 170 5280 170 {}
N 2130 380 2342 380 {}
N 2342 380 2342 400 {}
N 2342 400 2530 400 {}
N 2660 380 3724 380 {}
N 3724 380 3724 220 {}
N 3724 220 4740 220 {}
N 4860 190 5106 190 {}
N 5106 190 5106 210 {}
N 5106 210 5280 210 {}
N 2680 2090 2864 2090 {}
N 2864 2090 2864 2130 {}
N 2864 2130 3120 2130 {}
N 2680 2090 2876 2090 {}
N 2876 2090 2876 2700 {}
N 2876 2700 3120 2700 {}
N 3760 1520 3958 1520 {}
N 3958 1520 3958 950 {}
N 3958 950 4180 950 {}
N 2130 570 2330 570 {}
N 2330 570 2330 540 {}
N 2330 540 2530 540 {}
N 2130 760 2342 760 {}
N 2342 760 2342 560 {}
N 2342 560 2530 560 {}
N 2130 950 2354 950 {}
N 2354 950 2354 600 {}
N 2354 600 2530 600 {}
N 2130 1140 2366 1140 {}
N 2366 1140 2366 580 {}
N 2366 580 2530 580 {}
N 2680 570 2844 570 {}
N 2844 570 2844 400 {}
N 2844 400 3080 400 {}
N 3230 380 3406 380 {}
N 3406 380 3406 970 {}
N 3406 970 3630 970 {}
N 3780 950 3968 950 {}
N 3968 950 3968 740 {}
N 3968 740 4180 740 {}
N 2130 1520 2330 1520 {}
N 2330 1520 2330 730 {}
N 2330 730 2530 730 {}
N 2130 1710 2342 1710 {}
N 2342 1710 2342 750 {}
N 2342 750 2530 750 {}
N 2130 1900 2354 1900 {}
N 2354 1900 2354 790 {}
N 2354 790 2530 790 {}
N 2130 2090 2366 2090 {}
N 2366 2090 2366 770 {}
N 2366 770 2530 770 {}
N 2680 760 2844 760 {}
N 2844 760 2844 590 {}
N 2844 590 3080 590 {}
N 3210 570 3396 570 {}
N 3396 570 3396 1160 {}
N 3396 1160 3630 1160 {}
N 3760 1140 3958 1140 {}
N 3958 1140 3958 780 {}
N 3958 780 4180 780 {}
N 4330 760 4530 760 {}
N 4530 760 4530 590 {}
N 4530 590 4730 590 {}
N 4880 570 5092 570 {}
N 5092 570 5092 550 {}
N 5092 550 5280 550 {}
N 2660 1520 3444 1520 {}
N 3444 1520 3444 970 {}
N 3444 970 4180 970 {}
N 4310 950 4831 950 {}
N 4831 950 4831 590 {}
N 4831 590 5280 590 {}
N 2130 3610 2294 3610 {}
N 2294 3610 2294 1920 {}
N 2294 1920 2530 1920 {}
N 4310 190 4771 190 {}
N 4771 190 4771 -20 {}
N 4771 -20 5280 -20 {}
N 2680 1710 2868 1710 {}
N 2868 1710 2868 1730 {}
N 2868 1730 3080 1730 {}
N 1560 3040 1775 3040 {}
N 1775 3040 1775 3830 {}
N 1775 3830 1990 3830 {}
N 2110 3800 2607 3800 {}
N 2607 3800 2607 2640 {}
N 2607 2640 3080 2640 {}
N 1550 1330 1789 1330 {}
N 1789 1330 1789 1120 {}
N 1789 1120 1980 1120 {}
N 1550 1330 1801 1330 {}
N 1801 1330 1801 1880 {}
N 1801 1880 1980 1880 {}
N 1550 570 1729 570 {}
N 1729 570 1729 570 {}
N 1729 570 1980 570 {}
N 1550 570 1741 570 {}
N 1741 570 1741 1710 {}
N 1741 1710 1980 1710 {}
N 1550 190 3128 190 {}
N 3128 190 3128 360 {}
N 3128 360 4730 360 {}
N 1550 190 2590 190 {}
N 2590 190 2590 930 {}
N 2590 930 3630 930 {}
N 1550 190 2327 190 {}
N 2327 190 2327 550 {}
N 2327 550 3080 550 {}
N 1550 760 2614 760 {}
N 2614 760 2614 1140 {}
N 2614 1140 3630 1140 {}
N 1550 2660 1801 2660 {}
N 1801 2660 1801 3060 {}
N 1801 3060 1980 3060 {}
N 1550 0 1729 0 {}
N 1729 0 1729 400 {}
N 1729 400 1980 400 {}
N 1550 2090 2291 2090 {}
N 2291 2090 2291 2260 {}
N 2291 2260 3080 2260 {}
N 2100 3420 2303 3420 {}
N 2303 3420 2303 1730 {}
N 2303 1730 2530 1730 {}
N 1560 2470 1770 2470 {}
N 1770 2470 1770 2300 {}
N 1770 2300 1980 2300 {}
N 1560 2470 1782 2470 {}
N 1782 2470 1782 3250 {}
N 1782 3250 1980 3250 {}
N 2110 3230 2344 3230 {}
N 2344 3230 2344 -20 {}
N 2344 -20 2530 -20 {}
N 2110 3230 2356 3230 {}
N 2356 3230 2356 1310 {}
N 2356 1310 2530 1310 {}
N 2110 3230 2284 3230 {}
N 2284 3230 2284 2260 {}
N 2284 2260 2530 2260 {}
N 1560 1900 1746 1900 {}
N 1746 1900 1746 2870 {}
N 1746 2870 1980 2870 {}
N 1560 1900 1758 1900 {}
N 1758 1900 1758 1350 {}
N 1758 1350 1980 1350 {}
N 2110 2850 2320 2850 {}
N 2320 2850 2320 0 {}
N 2320 0 2530 0 {}
N 2110 2850 2332 2850 {}
N 2332 2850 2332 1330 {}
N 2332 1330 2530 1330 {}
N 2110 2850 2344 2850 {}
N 2344 2850 2344 2070 {}
N 2344 2070 2530 2070 {}
N 3680 4380 3736 4380 {}
N 3736 4380 3736 3020 {}
N 3736 3020 1980 3020 {}
N 3680 4380 3664 4380 {}
N 3664 4380 3664 360 {}
N 3664 360 1980 360 {}
N 3680 4380 3676 4380 {}
N 3676 4380 3676 1500 {}
N 3676 1500 2530 1500 {}
N 3680 4380 3688 4380 {}
N 3688 4380 3688 2680 {}
N 3688 2680 3080 2680 {}
N 3680 4380 5040 4380 {}
N 5040 4380 5040 1140 {}
N 5040 1140 6400 1140 {}
N 4780 1720 4812 1720 {}
N 4812 1720 4812 1330 {}
N 4812 1330 1430 1330 {}
N 4780 1720 4824 1720 {}
N 4824 1720 4824 360 {}
N 4824 360 1430 360 {}
N 4780 1720 4836 1720 {}
N 4836 1720 4836 1500 {}
N 4836 1500 1430 1500 {}
N 4780 1720 4764 1720 {}
N 4764 1720 4764 1880 {}
N 4764 1880 3630 1880 {}
N 4780 1720 4776 1720 {}
N 4776 1720 4776 550 {}
N 4776 550 1980 550 {}
N 4780 1720 4788 1720 {}
N 4788 1720 4788 1690 {}
N 4788 1690 1980 1690 {}
N 5330 960 5350 960 {}
N 5350 960 5350 570 {}
N 5350 570 1430 570 {}
N 5330 960 5362 960 {}
N 5362 960 5362 400 {}
N 5362 400 1430 400 {}
N 5330 960 5374 960 {}
N 5374 960 5374 1310 {}
N 5374 1310 3630 1310 {}
N 5330 960 5386 960 {}
N 5386 960 5386 1540 {}
N 5386 1540 1430 1540 {}
N 5330 960 5314 960 {}
N 5314 960 5314 1140 {}
N 5314 1140 1980 1140 {}
N 5330 960 5326 960 {}
N 5326 960 5326 1900 {}
N 5326 1900 1980 1900 {}
N 5880 390 5888 390 {}
N 5888 390 5888 190 {}
N 5888 190 1430 190 {}
N 5880 390 5900 390 {}
N 5900 390 5900 -20 {}
N 5900 -20 1980 -20 {}
N 5880 390 5912 390 {}
N 5912 390 5912 2300 {}
N 5912 2300 1430 2300 {}
N 5880 10 5924 10 {}
N 5924 10 5924 1110 {}
N 5924 1110 1440 1110 {}
N 5880 10 5936 10 {}
N 5936 10 5936 2260 {}
N 5936 2260 1430 2260 {}
N 5880 10 5864 10 {}
N 5864 10 5864 1120 {}
N 5864 1120 3630 1120 {}
N 5880 10 5876 10 {}
N 5876 10 5876 40 {}
N 5876 40 5320 40 {}
N 3760 3040 3958 3040 {}
N 3958 3040 3958 1500 {}
N 3958 1500 4180 1500 {}
N 3760 3040 3780 3040 {}
N 3780 3040 3780 1920 {}
N 3780 1920 3080 1920 {}
N 3760 3040 5092 3040 {}
N 5092 3040 5092 570 {}
N 5092 570 6400 570 {}
N 3230 1710 3454 1710 {}
N 3454 1710 3454 3020 {}
N 3454 3020 3630 3020 {}
N 3680 2480 3736 2480 {}
N 3736 2480 3736 3210 {}
N 3736 3210 1980 3210 {}
N 3680 2480 3664 2480 {}
N 3664 2480 3664 1920 {}
N 3664 1920 1430 1920 {}
N 5880 770 5876 770 {}
N 5876 770 5876 1880 {}
N 5876 1880 1430 1880 {}
N 5880 770 5888 770 {}
N 5888 770 5888 970 {}
N 5888 970 1430 970 {}
N 5880 770 5900 770 {}
N 5900 770 5900 740 {}
N 5900 740 3630 740 {}
N 5880 200 5912 200 {}
N 5912 200 5912 2450 {}
N 5912 2450 1430 2450 {}
N 5880 200 5924 200 {}
N 5924 200 5924 2830 {}
N 5924 2830 1980 2830 {}
N 5880 200 5936 200 {}
N 5936 200 5936 2450 {}
N 5936 2450 1980 2450 {}
N 5880 200 5864 200 {}
N 5864 200 5864 170 {}
N 5864 170 3630 170 {}
N 3210 1900 3396 1900 {}
N 3396 1900 3396 3060 {}
N 3396 3060 3630 3060 {}
N 350 190 878 190 {}
N 878 190 878 2090 {}
N 878 2090 1430 2090 {}
N 350 190 2265 190 {}
N 2265 190 2265 1540 {}
N 2265 1540 4180 1540 {}
N 350 190 1727 190 {}
N 1727 190 1727 1690 {}
N 1727 1690 3080 1690 {}
N 3210 2280 3454 2280 {}
N 3454 2280 3454 2510 {}
N 3454 2510 3650 2510 {}
N 3210 2280 4566 2280 {}
N 4566 2280 4566 800 {}
N 4566 800 5850 800 {}
N 3210 2280 4494 2280 {}
N 4494 2280 4494 230 {}
N 4494 230 5850 230 {}
N 3210 2280 3406 2280 {}
N 3406 2280 3406 3650 {}
N 3406 3650 3650 3650 {}
N 3210 2280 3418 2280 {}
N 3418 2280 3418 2700 {}
N 3418 2700 3650 2700 {}
N 3210 2280 3430 2280 {}
N 3430 2280 3430 4220 {}
N 3430 4220 3650 4220 {}
N 3210 2280 3442 2280 {}
N 3442 2280 3442 4600 {}
N 3442 4600 3650 4600 {}
N 3210 2280 3454 2280 {}
N 3454 2280 3454 4790 {}
N 3454 4790 3650 4790 {}
N 3210 2280 3466 2280 {}
N 3466 2280 3466 5550 {}
N 3466 5550 3650 5550 {}
N 3210 2280 3394 2280 {}
N 3394 2280 3394 5360 {}
N 3394 5360 3650 5360 {}
N 3210 2280 3406 2280 {}
N 3406 2280 3406 5740 {}
N 3406 5740 3650 5740 {}
N 3210 2280 3418 2280 {}
N 3418 2280 3418 5170 {}
N 3418 5170 3650 5170 {}
N 3210 2280 3980 2280 {}
N 3980 2280 3980 1750 {}
N 3980 1750 4750 1750 {}
N 3210 2280 4267 2280 {}
N 4267 2280 4267 990 {}
N 4267 990 5300 990 {}
N 3210 2280 4554 2280 {}
N 4554 2280 4554 420 {}
N 4554 420 5850 420 {}
N 3210 2280 4566 2280 {}
N 4566 2280 4566 40 {}
N 4566 40 5850 40 {}
N 3210 2280 3394 2280 {}
N 3394 2280 3394 4410 {}
N 3394 4410 3650 4410 {}
N 3210 2280 3406 2280 {}
N 3406 2280 3406 6120 {}
N 3406 6120 3650 6120 {}
N 3210 2280 3418 2280 {}
N 3418 2280 3418 6310 {}
N 3418 6310 3650 6310 {}
N 3210 2280 3430 2280 {}
N 3430 2280 3430 5930 {}
N 3430 5930 3650 5930 {}
N 3210 2280 3442 2280 {}
N 3442 2280 3442 6880 {}
N 3442 6880 3650 6880 {}
N 3210 2280 3454 2280 {}
N 3454 2280 3454 6500 {}
N 3454 6500 3650 6500 {}
N 3210 2280 3466 2280 {}
N 3466 2280 3466 6690 {}
N 3466 6690 3650 6690 {}
N 3210 2280 3394 2280 {}
N 3394 2280 3394 4980 {}
N 3394 4980 3650 4980 {}
N 4330 1520 4516 1520 {}
N 4516 1520 4516 1180 {}
N 4516 1180 4750 1180 {}
N 4330 1520 4528 1520 {}
N 4528 1520 4528 1370 {}
N 4528 1370 4750 1370 {}
N 4330 1520 4540 1520 {}
N 4540 1520 4540 1560 {}
N 4540 1560 4750 1560 {}
N 4330 1520 4552 1520 {}
N 4552 1520 4552 1940 {}
N 4552 1940 4750 1940 {}
N 4330 1520 4564 1520 {}
N 4564 1520 4564 2130 {}
N 4564 2130 4750 2130 {}
N 4330 1520 4576 1520 {}
N 4576 1520 4576 2320 {}
N 4576 2320 4750 2320 {}
N 4330 1520 4504 1520 {}
N 4504 1520 4504 2510 {}
N 4504 2510 4750 2510 {}
N 4330 1520 4516 1520 {}
N 4516 1520 4516 2700 {}
N 4516 2700 4750 2700 {}
N 4330 1520 5078 1520 {}
N 5078 1520 5078 610 {}
N 5078 610 5850 610 {}
N 3680 3620 3700 3620 {}
N 3700 3620 3700 0 {}
N 3700 0 1430 0 {}
N 3680 3620 3712 3620 {}
N 3712 3620 3712 2110 {}
N 3712 2110 3080 2110 {}
N 3680 3620 5064 3620 {}
N 5064 3620 5064 760 {}
N 5064 760 6400 760 {}
N 3680 2670 3736 2670 {}
N 3736 2670 3736 1350 {}
N 3736 1350 3080 1350 {}
N 3680 2670 5004 2670 {}
N 5004 2670 5004 380 {}
N 5004 380 6400 380 {}
N 3680 4190 3676 4190 {}
N 3676 4190 3676 2490 {}
N 3676 2490 3080 2490 {}
N 3680 4190 5028 4190 {}
N 5028 4190 5028 950 {}
N 5028 950 6400 950 {}
N 3680 4570 3700 4570 {}
N 3700 4570 3700 2870 {}
N 3700 2870 3080 2870 {}
N 3680 4570 5052 4570 {}
N 5052 4570 5052 1330 {}
N 5052 1330 6400 1330 {}
N 3680 4760 3724 4760 {}
N 3724 4760 3724 3060 {}
N 3724 3060 3080 3060 {}
N 3680 4760 5076 4760 {}
N 5076 4760 5076 1520 {}
N 5076 1520 6400 1520 {}
N 3680 5520 3664 5520 {}
N 3664 5520 3664 3630 {}
N 3664 3630 3080 3630 {}
N 3680 5520 5016 5520 {}
N 5016 5520 5016 2090 {}
N 5016 2090 6400 2090 {}
N 3680 5330 3688 5330 {}
N 3688 5330 3688 3440 {}
N 3688 3440 3080 3440 {}
N 3680 5330 5040 5330 {}
N 5040 5330 5040 1900 {}
N 5040 1900 6400 1900 {}
N 3680 5710 3712 5710 {}
N 3712 5710 3712 3820 {}
N 3712 3820 3080 3820 {}
N 3680 5710 5064 5710 {}
N 5064 5710 5064 2280 {}
N 5064 2280 6400 2280 {}
N 3680 5140 3736 5140 {}
N 3736 5140 3736 3250 {}
N 3736 3250 3080 3250 {}
N 3680 5140 5004 5140 {}
N 5004 5140 5004 1710 {}
N 5004 1710 6400 1710 {}
N 2110 2280 2576 2280 {}
N 2576 2280 2576 730 {}
N 2576 730 3090 730 {}
N 2110 2280 3413 2280 {}
N 3413 2280 3413 730 {}
N 3413 730 4740 730 {}
N 2110 2280 3145 2280 {}
N 3145 2280 3145 930 {}
N 3145 930 4180 930 {}
N 2110 2280 4267 2280 {}
N 4267 2280 4267 190 {}
N 4267 190 6400 190 {}
N 350 1710 1189 1710 {}
N 1189 1710 1189 3590 {}
N 1189 3590 1980 3590 {}
N 350 1710 1476 1710 {}
N 1476 1710 1476 1710 {}
N 1476 1710 2530 1710 {}
N 350 1710 1949 1710 {}
N 1949 1710 1949 2480 {}
N 1949 2480 3620 2480 {}
N 350 1710 3061 1710 {}
N 3061 1710 3061 770 {}
N 3061 770 5820 770 {}
N 350 1710 3073 1710 {}
N 3073 1710 3073 200 {}
N 3073 200 5820 200 {}
N 350 1710 1985 1710 {}
N 1985 1710 1985 3620 {}
N 1985 3620 3620 3620 {}
N 350 1710 1997 1710 {}
N 1997 1710 1997 2670 {}
N 1997 2670 3620 2670 {}
N 350 1710 2009 1710 {}
N 2009 1710 2009 4190 {}
N 2009 4190 3620 4190 {}
N 350 1710 2021 1710 {}
N 2021 1710 2021 4570 {}
N 2021 4570 3620 4570 {}
N 350 1710 1949 1710 {}
N 1949 1710 1949 4760 {}
N 1949 4760 3620 4760 {}
N 350 1710 1961 1710 {}
N 1961 1710 1961 5520 {}
N 1961 5520 3620 5520 {}
N 350 1710 1973 1710 {}
N 1973 1710 1973 5330 {}
N 1973 5330 3620 5330 {}
N 350 1710 1985 1710 {}
N 1985 1710 1985 5710 {}
N 1985 5710 3620 5710 {}
N 350 1710 1997 1710 {}
N 1997 1710 1997 5140 {}
N 1997 5140 3620 5140 {}
N 350 1710 2559 1710 {}
N 2559 1710 2559 1720 {}
N 2559 1720 4720 1720 {}
N 350 1710 2846 1710 {}
N 2846 1710 2846 960 {}
N 2846 960 5270 960 {}
N 350 1710 3049 1710 {}
N 3049 1710 3049 390 {}
N 3049 390 5820 390 {}
N 350 1710 3061 1710 {}
N 3061 1710 3061 10 {}
N 3061 10 5820 10 {}
N 350 1710 1973 1710 {}
N 1973 1710 1973 4380 {}
N 1973 4380 3620 4380 {}
N 350 1710 1985 1710 {}
N 1985 1710 1985 6090 {}
N 1985 6090 3620 6090 {}
N 350 1710 1997 1710 {}
N 1997 1710 1997 6280 {}
N 1997 6280 3620 6280 {}
N 350 1710 2009 1710 {}
N 2009 1710 2009 5900 {}
N 2009 5900 3620 5900 {}
N 350 1710 2021 1710 {}
N 2021 1710 2021 6850 {}
N 2021 6850 3620 6850 {}
N 350 1710 1949 1710 {}
N 1949 1710 1949 6470 {}
N 1949 6470 3620 6470 {}
N 350 1710 1961 1710 {}
N 1961 1710 1961 6660 {}
N 1961 6660 3620 6660 {}
N 350 1710 1973 1710 {}
N 1973 1710 1973 4950 {}
N 1973 4950 3620 4950 {}
N 350 1710 890 1710 {}
N 890 1710 890 1710 {}
N 890 1710 1430 1710 {}
N 1550 1710 3147 1710 {}
N 3147 1710 3147 1150 {}
N 3147 1150 4720 1150 {}
N 1550 1710 3159 1710 {}
N 3159 1710 3159 1340 {}
N 3159 1340 4720 1340 {}
N 1550 1710 3171 1710 {}
N 3171 1710 3171 1530 {}
N 3171 1530 4720 1530 {}
N 1550 1710 3099 1710 {}
N 3099 1710 3099 1910 {}
N 3099 1910 4720 1910 {}
N 1550 1710 3111 1710 {}
N 3111 1710 3111 2100 {}
N 3111 2100 4720 2100 {}
N 1550 1710 3123 1710 {}
N 3123 1710 3123 2290 {}
N 3123 2290 4720 2290 {}
N 1550 1710 3135 1710 {}
N 3135 1710 3135 2480 {}
N 3135 2480 4720 2480 {}
N 1550 1710 3147 1710 {}
N 3147 1710 3147 2670 {}
N 3147 2670 4720 2670 {}
N 1550 1710 3709 1710 {}
N 3709 1710 3709 580 {}
N 3709 580 5820 580 {}
N 1550 2850 1801 2850 {}
N 1801 2850 1801 3420 {}
N 1801 3420 1980 3420 {}
N 1550 2850 1729 2850 {}
N 1729 2850 1729 3630 {}
N 1729 3630 1980 3630 {}
N 350 760 1691 760 {}
N 1691 760 1691 1310 {}
N 1691 1310 3080 1310 {}
N 350 760 1428 760 {}
N 1428 760 1428 170 {}
N 1428 170 2530 170 {}
N 350 760 1715 760 {}
N 1715 760 1715 2070 {}
N 1715 2070 3080 2070 {}
N 350 760 1452 760 {}
N 1452 760 1452 1880 {}
N 1452 1880 2530 1880 {}
N 350 760 1464 760 {}
N 1464 760 1464 1690 {}
N 1464 1690 2530 1690 {}
N 350 760 2021 760 {}
N 2021 760 2021 6050 {}
N 2021 6050 3620 6050 {}
N 350 760 854 760 {}
N 854 760 854 2850 {}
N 854 2850 1430 2850 {}
N 5880 580 6116 580 {}
N 6116 580 6116 0 {}
N 6116 0 6400 0 {}
N 3680 6090 3688 6090 {}
N 3688 6090 3688 2450 {}
N 3688 2450 3080 2450 {}
N 3680 6090 3700 6090 {}
N 3700 6090 3700 3790 {}
N 3700 3790 1990 3790 {}
N 3680 6090 3712 6090 {}
N 3712 6090 3712 6240 {}
N 3712 6240 3620 6240 {}
N 3680 6280 3724 6280 {}
N 3724 6280 3724 2830 {}
N 3724 2830 3080 2830 {}
N 3680 6280 3736 6280 {}
N 3736 6280 3736 3810 {}
N 3736 3810 1990 3810 {}
N 3680 6280 3664 6280 {}
N 3664 6280 3664 5860 {}
N 3664 5860 3620 5860 {}
N 3680 5900 3676 5900 {}
N 3676 5900 3676 3020 {}
N 3676 3020 3080 3020 {}
N 3680 5900 3688 5900 {}
N 3688 5900 3688 3070 {}
N 3688 3070 1440 3070 {}
N 3680 5900 3700 5900 {}
N 3700 5900 3700 6810 {}
N 3700 6810 3620 6810 {}
N 3680 6850 3712 6850 {}
N 3712 6850 3712 3590 {}
N 3712 3590 3080 3590 {}
N 3680 6850 3724 6850 {}
N 3724 6850 3724 3770 {}
N 3724 3770 1990 3770 {}
N 3680 6850 3736 6850 {}
N 3736 6850 3736 6430 {}
N 3736 6430 3620 6430 {}
N 3680 6470 3664 6470 {}
N 3664 6470 3664 3400 {}
N 3664 3400 3080 3400 {}
N 3680 6470 3676 6470 {}
N 3676 6470 3676 6620 {}
N 3676 6620 3620 6620 {}
N 3680 6660 3688 6660 {}
N 3688 6660 3688 3780 {}
N 3688 3780 3080 3780 {}
N 3680 6660 3700 6660 {}
N 3700 6660 3700 3050 {}
N 3700 3050 1440 3050 {}
N 3680 6660 3712 6660 {}
N 3712 6660 3712 4910 {}
N 3712 4910 3620 4910 {}
N 3680 4950 3724 4950 {}
N 3724 4950 3724 3210 {}
N 3724 3210 3080 3210 {}
N 2660 1900 2906 1900 {}
N 2906 1900 2906 2300 {}
N 2906 2300 3080 2300 {}
N 2660 1900 2834 1900 {}
N 2834 1900 2834 1880 {}
N 2834 1880 3080 1880 {}
N 350 0 1966 0 {}
N 1966 0 1966 1690 {}
N 1966 1690 3630 1690 {}
N 350 380 1978 380 {}
N 1978 380 1978 2070 {}
N 1978 2070 3630 2070 {}
N 350 570 1990 570 {}
N 1990 570 1990 2260 {}
N 1990 2260 3630 2260 {}
N 350 1140 2002 1140 {}
N 2002 1140 2002 2830 {}
N 2002 2830 3630 2830 {}
N 350 1330 2014 1330 {}
N 2014 1330 2014 3210 {}
N 2014 3210 3630 3210 {}
N 350 1520 2026 1520 {}
N 2026 1520 2026 3400 {}
N 2026 3400 3630 3400 {}
N 350 1900 1954 1900 {}
N 1954 1900 1954 3780 {}
N 1954 3780 3630 3780 {}
N 350 950 1966 950 {}
N 1966 950 1966 1500 {}
N 1966 1500 3630 1500 {}
N 350 950 1978 950 {}
N 1978 950 1978 3970 {}
N 1978 3970 3630 3970 {}
N 4780 1150 4800 1150 {}
N 4800 1150 4800 1730 {}
N 4800 1730 3630 1730 {}
N 4780 1150 4812 1150 {}
N 4812 1150 4812 2070 {}
N 4812 2070 1980 2070 {}
N 4780 1340 4824 1340 {}
N 4824 1340 4824 2110 {}
N 4824 2110 3630 2110 {}
N 4780 1340 4836 1340 {}
N 4836 1340 4836 1920 {}
N 4836 1920 1980 1920 {}
N 4780 1530 4764 1530 {}
N 4764 1530 4764 2300 {}
N 4764 2300 3630 2300 {}
N 4780 1530 4776 1530 {}
N 4776 1530 4776 1730 {}
N 4776 1730 1980 1730 {}
N 4780 1910 4788 1910 {}
N 4788 1910 4788 2870 {}
N 4788 2870 3630 2870 {}
N 4780 1910 4800 1910 {}
N 4800 1910 4800 1500 {}
N 4800 1500 1980 1500 {}
N 4780 2100 4812 2100 {}
N 4812 2100 4812 3250 {}
N 4812 3250 3630 3250 {}
N 4780 2100 4824 2100 {}
N 4824 2100 4824 930 {}
N 4824 930 1980 930 {}
N 4780 2290 4836 2290 {}
N 4836 2290 4836 3440 {}
N 4836 3440 3630 3440 {}
N 4780 2290 4764 2290 {}
N 4764 2290 4764 1160 {}
N 4764 1160 1980 1160 {}
N 4780 2480 4776 2480 {}
N 4776 2480 4776 3820 {}
N 4776 3820 3630 3820 {}
N 4780 2480 4788 2480 {}
N 4788 2480 4788 590 {}
N 4788 590 1980 590 {}
N 4780 2670 4800 2670 {}
N 4800 2670 4800 4010 {}
N 4800 4010 3630 4010 {}
N 4780 2670 4812 2670 {}
N 4812 2670 4812 740 {}
N 4812 740 1980 740 {}
